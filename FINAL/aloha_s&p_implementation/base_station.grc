options:
  parameters:
    author: malinda
    generate_options: qt_gui
    id: user_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '.5'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '11100001010110101110100010010011'
    bps: '1'
    threshold: '1'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: spr
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: user1_freq
  id: variable
  parameters:
    value: 2.5e9
  states: {}
- name: user2_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: Prepends Header to the Payload Streamwise
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Unpack the symbols into bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Channel Simulation
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Decode a constellation's points
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: QPSK Modulator
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    comment: Scans for the initial header and places length tags
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Decodes differentially encoded bits
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    comment: Provides Linear Equalization
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: Maps decoded symbols to original symbols
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    comment: Generates Header
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Performs Clock Recovery
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import queue
      import time
      import random
      import struct

      class blk(gr.sync_block):
          """
          Embedded Python Block for User Node 
          Performs message transmission and reception via two threads using PDUs
          Uses Stop and Wait ARQ to ensure packet transmission reliably
          Uses ALOHA backoff to avoid collisions due to simultaneous transmissions

          """
          
          def __init__(self, node_id=1, aloha_prob=0.3, timeout=1.0, max_retries=3):
              """
              Arguments:
                  node_id: Unique identifier for this node (1-255)
                  aloha_prob: Transmission probability for ALOHA (0.0-1.0)
                  timeout: ARQ timeout in seconds
                  max_retries: Maximum retransmission attempts
              """
              gr.sync_block.__init__(
                  self,
                  name='Mesh Packet Comm with sync',
                  in_sig=None,
                  out_sig=None
              )
              
              # Node configuration
              self.node_id = node_id
              self.aloha_prob = aloha_prob
              self.timeout = timeout
              self.max_retries = max_retries
              
              # Packet parameters
              self.PREAMBLE = bytes([0xAA, 0xAA, 0xAA, 0xAA])
              self.SYNC_WORD = bytes([0x2D, 0xD4])
              self.MAX_PAYLOAD = 255
              self.HEADER_SIZE = 8  # preamble(4) + sync(2) + src(1) + dst(1)
              self.CRC_SIZE = 2
              
              # Packet types
              self.PKT_DATA = 0x01
              self.PKT_ACK = 0x02
              
              # CRC-16 CCITT lookup table
              self.crc_table = self.generate_crc_table()
              
              # State management
              self.tx_queue = queue.Queue()
              self.rx_queue = queue.Queue()
              self.ack_queue = queue.Queue()
              self.pending_ack = {}
              self.seq_num_tx = 0
              self.seq_num_rx = {}
              self.rx_buffer = bytes()
              self.redirecting = False
              
              # Statistics
              self.stats = {
                  'packets_sent': 0,
                  'packets_received': 0,
                  'acks_sent': 0,
                  'acks_received': 0,
                  'retransmissions': 0,
                  'crc_errors': 0
              }
              
              # Threading
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_handler)
              self.rx_thread = threading.Thread(target=self.rx_handler)
              self.lock = threading.Lock()
              
              # Message ports
              
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_in(pmt.intern('sync_cmd'))
              
              self.message_port_register_out(pmt.intern('feedback'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              # Set message handlers
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg_in)
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu_in)
              self.set_msg_handler(pmt.intern('sync_cmd'), self.handle_sync_cmd)
              
              # Start threads
              self.tx_thread.start()
              self.rx_thread.start()
              
              print(f"[Node {self.node_id}] Initialized - Ready for communication")
          
          def generate_crc_table(self):
              """Generate CRC-16 CCITT lookup table"""
              poly = 0x1021
              table = []
              for i in range(256):
                  crc = i << 8
                  for j in range(8):
                      if crc & 0x8000:
                          crc = ((crc << 1) ^ poly) & 0xFFFF
                      else:
                          crc = (crc << 1) & 0xFFFF
                  table.append(crc)
              return table
          
          def calculate_crc16(self, data):
              """Calculate CRC-16 CCITT for given data"""
              crc = 0xFFFF
              for byte in data:
                  tbl_idx = ((crc >> 8) ^ byte) & 0xFF
                  crc = ((crc << 8) ^ self.crc_table[tbl_idx]) & 0xFFFF
              return crc
          
          def handle_msg_in(self, msg):
              """Handle incoming messages from GUI"""
              try:
                  #redundant
                  # Handle string messages directly
                  if pmt.is_symbol(msg):
                      # Simple text message format: "dst_id:message"
                      text = pmt.symbol_to_string(msg)
                      if ':' in text:
                          parts = text.split(':', 1)
                          try:
                              dst_id = int(parts[0])
                              data = parts[1].encode()
                              self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                              print(f"[Node {self.node_id}] Queued message to {dst_id}: {parts[1]}")
                          except ValueError:
                              print(f"[Node {self.node_id}] Invalid destination ID")
                  
                  #redundant
                  # Handle dictionary messages
                  elif pmt.is_dict(msg):
                      meta = pmt.to_python(msg)
                      if 'dst' in meta and 'data' in meta:
                          dst_id = meta['dst']
                          data = meta['data'].encode() if isinstance(meta['data'], str) else meta['data']
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued message to {dst_id}")
                  
                  # Handle pair messages (PDU format)
                  elif pmt.is_pair(msg):
                      meta = pmt.to_python(pmt.car(msg))
                      data = pmt.to_python(pmt.cdr(msg))
                      if isinstance(meta, dict) and 'dst' in meta:
                          dst_id = meta['dst']
                          if isinstance(data, str):
                              data = data.encode()
                          elif isinstance(data, list):
                              data = bytes(data)
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued message to {dst_id}")
                          
              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling msg_in: {e}")
          
          def handle_pdu_in(self, pdu):
              """Handle incoming PDUs from demodulator"""
              try:
                  # Extract PDU data
                  if pmt.is_pair(pdu):
                      meta = pmt.car(pdu)
                      data = pmt.cdr(pdu)
                      
                      # Convert to bytes
                      if pmt.is_u8vector(data):
                          print(f"User Port {self.node_id} activated")	
                          rx_bytes = bytes(pmt.u8vector_elements(data))	
                          self.rx_queue.put(rx_bytes)
                      elif pmt.is_uniform_vector(data):
                          # Handle float32 or other vector types
                          elements = pmt.to_python(data)
                          # Convert to bytes (assuming 8-bit symbols)
                          rx_bytes = bytes([int(x) & 0xFF for x in elements])
                          self.rx_queue.put(rx_bytes)
                          
              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling pdu_in: {e}")
          
          def create_packet(self, dst_id, seq_num, pkt_type, payload=b'', src_id=None):
              """Create a packet with headers and CRC

              src_id: if None, default to self.node_id; otherwise use provided source id
              """
              if src_id is None:
                  src = self.node_id
              else:
                  src = src_id & 0xFF

              packet = bytearray()
              
              # Add preamble and sync word
              packet.extend(self.PREAMBLE)
              packet.extend(self.SYNC_WORD)
              
              # Add header
              packet.append(src)           # Source ID (now param)
              packet.append(dst_id)         # Destination ID
              packet.append(seq_num)        # Sequence number
              packet.append(pkt_type)       # Packet type
              packet.append(len(payload))   # Payload length
              
              # Add payload
              if payload:
                  packet.extend(payload[:self.MAX_PAYLOAD])
              
              # Calculate and add CRC16
              crc_data = bytes(packet[len(self.PREAMBLE) + len(self.SYNC_WORD):])
              crc_val = self.calculate_crc16(crc_data)
              packet.extend(struct.pack('>H', crc_val))
              
              return bytes(packet)
          
          def parse_packet(self, data):
              """Parse received packet and validate CRC"""
              try:
                  # Find sync word
                  sync_idx = data.find(self.SYNC_WORD)
                  if sync_idx == -1:
                      return None
                  
                  # Check minimum packet size
                  start_idx = sync_idx + len(self.SYNC_WORD)
                  if len(data) < start_idx + 5 + self.CRC_SIZE:
                      return None
                  
                  # Extract header fields
                  src_id = data[start_idx]
                  dst_id = data[start_idx + 1]
                  seq_num = data[start_idx + 2]
                  pkt_type = data[start_idx + 3]
                  payload_len = data[start_idx + 4]
                  
                  # Check if we have complete packet
                  total_len = start_idx + 5 + payload_len + self.CRC_SIZE
                  if len(data) < total_len:
                      return None
                  
                  # Extract payload and CRC
                  payload = data[start_idx + 5:start_idx + 5 + payload_len]
                  rx_crc = struct.unpack('>H', data[total_len - self.CRC_SIZE:total_len])[0]
                  
                  # Verify CRC
                  crc_data = data[start_idx:total_len - self.CRC_SIZE]
                  calc_crc = self.calculate_crc16(crc_data)
                  
                  if rx_crc != calc_crc:
                      self.stats['crc_errors'] += 1
                      print(f"[Node {self.node_id}] CRC mismatch (expected: {calc_crc:04X}, got: {rx_crc:04X})")
                      return None
                  
                  return {
                      'src': src_id,
                      'dst': dst_id,
                      'seq': seq_num,
                      'type': pkt_type,
                      'payload': payload,
                      'consumed': total_len
                  }
              except Exception as e:
                  print(f"[Node {self.node_id}] Error parsing packet: {e}")
                  return None
          
          def send_sync_burst(self):
              """Sync Bursts are used before packet transmission to help syncing the SDRs"""
              burst = bytes(random.getrandbits(8) for _ in range(100))
              self.transmit_packet(burst)

          def handle_sync_cmd(self, cmd):
              """Allows for manual syncing if necessary via sync button in GUI"""
              burst = bytes(random.getrandbits(8) for _ in range(1000))
              self.transmit_packet(burst)

          def tx_handler(self):
              """Thread for handling packet transmission with ARQ"""
              while self.running:
                  try:
                      # Get message from queue (with timeout for thread safety)
                      try:
                          msg = self.tx_queue.get(timeout=0.1)
                      except queue.Empty:
                          continue
                      
                      # If this is a forwarded raw packet, send it once without ARQ
                      if msg.get('forward_raw', False):
                          try:
                              raw_packet = msg['raw_packet']
                              print(f"[Node {self.node_id}] TX: Forwarding raw packet (one-shot), length={len(raw_packet)}")
                              # Optionally sync before forwarding
                              self.send_sync_burst()
                              self.transmit_packet(raw_packet)
                              self.stats['packets_sent'] += 1
                          except Exception as e:
                              print(f"[Node {self.node_id}] forward send error: {e}")
                          continue
                      
                      # ALOHA: Random backoff for locally-originated packets
                      if random.random() > self.aloha_prob:
                          backoff_time = random.uniform(0.1, 0.5)
                          print(f"[Node {self.node_id}] ALOHA backoff {backoff_time:.2f}s")
                          time.sleep(backoff_time)
                          # Re-queue the message
                          self.tx_queue.put(msg)
                          continue
                      
                      # Prepare packet for locally-originated messages
                      with self.lock:
                          seq_num = self.seq_num_tx
                          self.seq_num_tx = (self.seq_num_tx + 1) % 256
                      
                      packet = self.create_packet(
                          msg['dst'],
                          seq_num,
                          msg['type'],
                          msg.get('data', b'')
                      )
                      
                      # Stop-and-Wait ARQ for locally-originated packets
                      retries = 0
                      ack_received = False

                      #self.send_sync_burst()
                      
                      while retries < self.max_retries and not ack_received:
                          # Transmit packet
                          print(f"[Node {self.node_id}] TX: Sending packet seq={seq_num} to node {msg['dst']} (attempt {retries + 1})")
                          # Attempt to sync before transmission
                          self.send_sync_burst()
                          self.transmit_packet(packet)
                          self.stats['packets_sent'] += 1
                          
                          if retries > 0:
                              self.stats['retransmissions'] += 1
                          
                          # Wait for ACK
                          ack_key = f"{msg['dst']}_{seq_num}"
                          timeout_time = time.time() + self.timeout
                          
                          while time.time() < timeout_time:
                              try:
                                  ack = self.ack_queue.get(timeout=0.1)
                                  if ack['key'] == ack_key:
                                      ack_received = True
                                      self.stats['acks_received'] += 1
                                      print(f"[Node {self.node_id}] TX: ACK received for seq={seq_num}")
                                      # Informing GUI of message acknowledgment success
                                      output = "TRUE"
                                      msg = pmt.intern(output)
                                      self.message_port_pub(pmt.intern('feedback'), msg)
                                      break
                              except queue.Empty:
                                  pass
                          
                          if not ack_received:
                              retries += 1
                              if retries < self.max_retries:
                                  print(f"[Node {self.node_id}] TX: Timeout, retry {retries}/{self.max_retries}")
                      
                      if not ack_received:
                          print(f"[Node {self.node_id}] TX: Failed to deliver packet seq={seq_num} after {self.max_retries} attempts")
                          # Informing GUI of message acknowledgment failure
                          output = "FALSE"
                          msg = pmt.intern(output)
                          self.message_port_pub(pmt.intern('feedback'), msg)
                          
                  except Exception as e:
                      print(f"[Node {self.node_id}] TX handler error: {e}")
          
          def rx_handler(self):
              """Thread for handling packet reception"""
              while self.running:
                  try:
                      # Get received data
                      try:
                          rx_data = self.rx_queue.get(timeout=0.1)
                      except queue.Empty:
                          continue
                      
                      # Add to buffer
                      self.rx_buffer += rx_data
                      
                      # Try to parse packets from buffer
                      while len(self.rx_buffer) > 0:
                          pkt = self.parse_packet(self.rx_buffer)
                          
                          if pkt is None:
                              # No valid packet found, remove first byte and try again
                              if len(self.rx_buffer) > 1:
                                  self.rx_buffer = self.rx_buffer[1:]
                              else:
                                  self.rx_buffer = bytes()
                              continue
                          
                          # Remove processed packet from buffer
                          self.rx_buffer = self.rx_buffer[pkt['consumed']:]
                          
                          # Check if packet is for this node or broadcast
                          if pkt['dst'] != self.node_id and pkt['dst'] != 0xFF:
                              # Forward the packet transparently (preserve original src and seq)
                              print(f"[Node {self.node_id}] RX: Forwarding packet from {pkt['src']} to {pkt['dst']}, seq={pkt['seq']}")
                              forward_packet = self.create_packet(
                                  dst_id = pkt['dst'],
                                  seq_num = pkt['seq'],
                                  pkt_type = pkt['type'],
                                  payload = pkt['payload'],
                                  src_id = pkt['src']   # preserve original source ID
                              )
                              # enqueue as a one-shot forward (no ARQ)
                              self.tx_queue.put({'forward_raw': True, 'raw_packet': forward_packet})
                              continue
                              
                          
                          # Handle based on packet type (packet is for this node or broadcast)
                          if pkt['type'] == self.PKT_DATA:
                              self.stats['packets_received'] += 1
                              print(f"[Node {self.node_id}] RX: Data packet from node {pkt['src']}, seq={pkt['seq']}")
                              
                              # Check for duplicate
                              is_duplicate = False
                              if pkt['src'] in self.seq_num_rx:
                                  if self.seq_num_rx[pkt['src']] == pkt['seq']:
                                      print(f"[Node {self.node_id}] RX: Duplicate packet detected")
                                      is_duplicate = True
                              
                              self.seq_num_rx[pkt['src']] = pkt['seq']
                              
                              # Send ACK only if this packet is addressed to this node
                              ack_packet = self.create_packet(
                                  pkt['src'],
                                  pkt['seq'],
                                  self.PKT_ACK
                              )
                              print(f"[Node {self.node_id}] RX: Sending ACK for seq={pkt['seq']}")
                              self.send_sync_burst()
                              self.transmit_packet(ack_packet)
                              self.stats['acks_sent'] += 1
                              
                              # Forward to application if not duplicate
                              if not is_duplicate:
                                  self.forward_to_app(pkt['src'], pkt['payload'])
                              
                          elif pkt['type'] == self.PKT_ACK:
                              # If ACK is for this node, consume it for locally-originated ARQ
                              if pkt['dst'] == self.node_id:
                                  print(f"[Node {self.node_id}] RX: ACK packet from node {pkt['src']}, seq={pkt['seq']} (for me)")
                                  ack_key = f"{pkt['src']}_{pkt['seq']}"
                                  self.ack_queue.put({'key': ack_key})
                              else:
                                  # ACK is meant for someone else; forward unchanged toward its destination
                                  print(f"[Node {self.node_id}] RX: ACK for node {pkt['dst']} — forwarding")
                                  forward_packet = self.create_packet(
                                      dst_id = pkt['dst'],
                                      seq_num = pkt['seq'],
                                      pkt_type = pkt['type'],
                                      payload = b'',
                                      src_id = pkt['src']   # preserve ACK's src (the node that generated the ACK)
                                  )
                                  self.tx_queue.put({'forward_raw': True, 'raw_packet': forward_packet})
                              
                  except Exception as e:
                      print(f"[Node {self.node_id}] RX handler error: {e}")
          
          def transmit_packet(self, packet):
              """Send packet to physical layer"""
              try:
                  # Convert to PDU format
                  vec = pmt.init_u8vector(len(packet), list(packet))
                  pdu = pmt.cons(pmt.PMT_NIL, vec)
                  
                  # Send to modulator
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)
                  
              except Exception as e:
                  print(f"[Node {self.node_id}] Error transmitting packet: {e}")
          
          def forward_to_app(self, src_id, data):
              """Forward received data to application/GUI"""
              try:
                  # Decode message
                  message = data.decode('utf-8', errors='ignore')
                  
                  # Create formatted output string
                  output = f"[From Node {src_id}]: {message}"
                  
                  # Send as simple string message
                  msg = pmt.intern(output)
                  self.message_port_pub(pmt.intern('msg_out'), msg)
                  
                  # Also send as dictionary for more complex processing
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("src"), pmt.from_long(src_id))
                  meta = pmt.dict_add(meta, pmt.intern("data"), pmt.intern(message))
                  
                  print(f"[Node {self.node_id}] Message delivered: {output}")
                  
              except Exception as e:
                  print(f"[Node {self.node_id}] Error forwarding to app: {e}")
          
          def work(self, input_items, output_items):
              """Main work function (not used for message passing blocks)"""
              return 0
          
          def stop(self):
              """Clean shutdown"""
              print(f"\n[Node {self.node_id}] Statistics:")
              print(f"  Packets sent: {self.stats['packets_sent']}")
              print(f"  Packets received: {self.stats['packets_received']}")
              print(f"  ACKs sent: {self.stats['acks_sent']}")
              print(f"  ACKs received: {self.stats['acks_received']}")
              print(f"  Retransmissions: {self.stats['retransmissions']}")
              print(f"  CRC errors: {self.stats['crc_errors']}")
              
              self.running = False
              if self.tx_thread.is_alive():
                  self.tx_thread.join()
              if self.rx_thread.is_alive():
                  self.rx_thread.join()
              return True
    aloha_prob: '0.6'
    comment: User 1
    max_retries: '100'
    node_id: '1'
    timeout: '0.2'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import pmt
      from datetime import datetime

      class WallpaperScrollArea(QtWidgets.QScrollArea):
          def __init__(self, bg_image="", parent=None):
              super().__init__(parent)
              self.setWidgetResizable(True)
              self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None

          def paintEvent(self, event):
              if self.bg_pixmap:
                  painter = QtGui.QPainter(self.viewport())
                  painter.drawPixmap(self.viewport().rect(), self.bg_pixmap)
              super().paintEvent(event)


      class _GuiPoster(QtCore.QObject):
          """Helper QObject to post strings into the Qt thread safely."""
          sig = QtCore.pyqtSignal(str)  # emits text payload

          def __init__(self):
              super().__init__()


      class messenger_gui(gr.basic_block):
          """
          WhatsApp-style Messenger GUI (GNU Radio embedded block).
          - Outgoing messages: published on message port "out" with address prepended as "addr:body"
          - Feedback port "feedback": updates delivery timestamp / failed status
          - Incoming messages: received on port "in_msg" (same format "addr:body") and displayed
            on the left in a different color.
          """

          def __init__(self, bg_image=""):
              gr.basic_block.__init__(
                  self,
                  name="Messenger GUI",
                  in_sig=None,
                  out_sig=None,
              )

              # Message ports
              self.message_port_register_out(pmt.intern("out"))    # outgoing messages
              self.message_port_register_out(pmt.intern("sync_cmd"))
              self.message_port_register_in(pmt.intern("feedback"))# delivery feedback
              self.message_port_register_in(pmt.intern("in_msg"))  # incoming messages from remote/devices

              # Bind handlers
              self.set_msg_handler(pmt.intern("feedback"), self._process_feedback)
              self.set_msg_handler(pmt.intern("in_msg"), self._receive_message)

              # Poster used to safely move messages to GUI thread
              self._poster = _GuiPoster()
              self._poster.sig.connect(self._display_incoming)  # connect to GUI-thread handler

              # Qt Application
              self.app = QtWidgets.QApplication.instance()
              if self.app is None:
                  self.app = QtWidgets.QApplication(sys.argv)

              # Main window
              self.qt_widget = QtWidgets.QWidget()
              self.qt_widget.setWindowTitle("Messenger GUI User 1")
              self.qt_widget.resize(640, 560)

              main_layout = QtWidgets.QVBoxLayout()
              main_layout.setContentsMargins(8, 8, 8, 8)
              main_layout.setSpacing(6)
              self.qt_widget.setLayout(main_layout)

              # Address selection bar
              addr_layout = QtWidgets.QHBoxLayout()
              addr_label = QtWidgets.QLabel("To:")
              addr_label.setStyleSheet("font-size: 18px; font-weight: bold;")
              addr_layout.addWidget(addr_label)

              self.addr_box = QtWidgets.QComboBox()
              self.addr_box.addItems([str(i) for i in range(1, 11)])  # 1..10 default
              self.addr_box.setFixedWidth(100)
              self.addr_box.setStyleSheet("font-size: 16px; padding: 4px;")
              addr_layout.addWidget(self.addr_box)
              addr_layout.addStretch()

              main_layout.addLayout(addr_layout)

              # Scroll area with background
              self.scroll_area = WallpaperScrollArea(bg_image=bg_image)
              self.scroll_area.setStyleSheet("border: none;")
              self.scroll_area.setWidgetResizable(True)
              main_layout.addWidget(self.scroll_area, stretch=1)

              # Chat container (vertical list of message widgets)
              self.chat_container = QtWidgets.QWidget()
              self.chat_layout = QtWidgets.QVBoxLayout()
              self.chat_layout.setAlignment(QtCore.Qt.AlignTop)
              self.chat_layout.setSpacing(10)
              self.chat_container.setLayout(self.chat_layout)
              self.chat_container.setStyleSheet("background: transparent;")
              self.scroll_area.setWidget(self.chat_container)

              # Input area (text entry + send)
              input_layout = QtWidgets.QHBoxLayout()
              self.input_box = QtWidgets.QLineEdit()
              self.input_box.setPlaceholderText("Type a message...")
              self.input_box.setMinimumHeight(40)
              self.input_box.setStyleSheet("""
                  QLineEdit {
                      border-radius: 12px;
                      padding: 8px;
                      background-color: rgba(255,255,255,0.95);
                      font-size: 16px;
                  }
              """)
              self.send_button = QtWidgets.QPushButton("Send")
              self.send_button.setMinimumHeight(40)
              self.send_button.setStyleSheet("""
                  QPushButton {
                      background-color: #4CAF50;
                      color: white;
                      border-radius: 10px;
                      padding: 8px 16px;
                      font-weight: bold;
                      font-size: 16px;
                  }
                  QPushButton:hover { background-color: #45a049; }
              """)
              input_layout.addWidget(self.input_box, stretch=1)
              input_layout.addWidget(self.send_button, stretch=0)
              main_layout.addLayout(input_layout)

              self.sync_button = QtWidgets.QPushButton("Sync")
              self.sync_button.setMinimumHeight(40)
              self.sync_button.setStyleSheet("""
                  QPushButton {
                      background-color: #4CAF50;
                      color: white;
                      border-radius: 10px;
                      padding: 8px 16px;
                      font-weight: bold;
                      font-size: 16px;
                  }
                  QPushButton:hover { background-color: #45a049; }
              """)
              input_layout.addWidget(self.sync_button, stretch=0)
              main_layout.addLayout(input_layout)

              # Connect GUI signals
              self.send_button.clicked.connect(self.send_message)
              self.input_box.returnPressed.connect(self.send_message)
              self.sync_button.clicked.connect(self.send_sync_cmd)

              # Track last sent message timestamp widget (simple approach)
              # If you want per-message tracking, change to a list/map of widgets per message id.
              self._last_message_timestamp = None

              # show window
              self.qt_widget.show()

          def send_sync_cmd(self):
              sync_cmd_message = "T"
              try:
                  self.message_port_pub(pmt.intern("sync_cmd"), pmt.intern(sync_cmd_message))
              except Exception:
                  # fallback to generic intern
                  self.message_port_pub(pmt.intern("sync_cmd"), pmt.intern(sync_cmd_message))

          def send_message(self):
              """Called from GUI thread when user presses Send or Enter."""
              text = self.input_box.text().strip()
              if not text:
                  return

              addr = self.addr_box.currentText().strip()
              full_msg = f"{addr}:{text}"

              # Publish as PMT symbol/string on 'out' port
              try:
                  self.message_port_pub(pmt.intern("out"), pmt.intern(full_msg))
              except Exception:
                  # fallback to generic intern
                  self.message_port_pub(pmt.intern("out"), pmt.intern(full_msg))

              # Build outgoing bubble (right side)
              container = QtWidgets.QWidget()
              vbox = QtWidgets.QVBoxLayout()
              vbox.setContentsMargins(0, 0, 0, 0)
              vbox.setSpacing(4)

              # Scrollable area for long messages
              scroll = QtWidgets.QScrollArea()
              scroll.setWidgetResizable(True)
              scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)
              scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              scroll.setFrameShape(QtWidgets.QFrame.NoFrame)
              scroll.setStyleSheet("background: transparent; border: none;")

              bubble = QtWidgets.QLabel(text)  # show only body (user-friendly)
              bubble.setWordWrap(False)
              bubble.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              bubble.setStyleSheet("""
                  QLabel {
                      background-color: qlineargradient(x1:0,y1:0,x2:1,y2:1, stop:0 #4CAF50, stop:1 #66BB6A);
                      color: white;
                      border-radius: 12px;
                      padding: 8px 12px;
                      font-size: 14px;
                  }
              """)
              # shadow
              effect = QtWidgets.QGraphicsDropShadowEffect()
              effect.setBlurRadius(6)
              effect.setXOffset(2)
              effect.setYOffset(2)
              effect.setColor(QtGui.QColor(0, 0, 0, 80))
              bubble.setGraphicsEffect(effect)

              scroll.setWidget(bubble)
              scroll.setMinimumWidth(160)
              scroll.setMaximumWidth(520)

              # Timestamp pill (initially 'Sending...')
              timestamp = QtWidgets.QLabel("Sending...")
              timestamp.setStyleSheet("""
                  QLabel {
                      background-color: #2196F3;
                      color: white;
                      font-size: 11px;
                      border-radius: 8px;
                      padding: 2px 6px;
                  }
              """)
              timestamp.setAlignment(QtCore.Qt.AlignRight)
              timestamp.setSizePolicy(QtWidgets.QSizePolicy.Fixed, QtWidgets.QSizePolicy.Fixed)

              vbox.addWidget(scroll, alignment=QtCore.Qt.AlignRight)
              vbox.addWidget(timestamp, alignment=QtCore.Qt.AlignRight)
              container.setLayout(vbox)
              container.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Fixed)

              # Add to chat layout (right aligned)
              self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignRight)

              # Force layout update and scroll to bottom
              bubble.adjustSize()
              scroll.adjustSize()
              container.adjustSize()
              self.chat_container.adjustSize()
              QtWidgets.QApplication.processEvents()
              QtCore.QTimer.singleShot(20, lambda: self.scroll_area.verticalScrollBar().setValue(
                  self.scroll_area.verticalScrollBar().maximum()
              ))

              # Clear input and store timestamp widget for feedback updates
              self.input_box.clear()
              self._last_message_timestamp = timestamp

          def _process_feedback(self, msg_pmt):
              """
              Handler for 'feedback' port. Expected feedback values:
                - "TRUE" => show delivery time
                - "FALSE" => show 'Failed'
              """
              try:
                  if pmt.is_symbol(msg_pmt) or pmt.is_string(msg_pmt):
                      fb = pmt.symbol_to_string(msg_pmt)
                  else:
                      py = pmt.to_python(msg_pmt)
                      fb = str(py)
              except Exception:
                  fb = "<unreadable feedback>"

              print(fb)
              # Update last timestamp widget if available (simple single-last approach)
              if self._last_message_timestamp:
                  if fb == "TRUE":
                      self._last_message_timestamp.setText(datetime.now().strftime("%H:%M:%S"))
                      self._last_message_timestamp.setStyleSheet("""
                          QLabel {
                              background-color: #2196F3;
                              color: white;
                              font-size: 11px;
                              border-radius: 8px;
                              padding: 2px 6px;
                          }
                      """)
                  elif fb == "FALSE":
                      self._last_message_timestamp.setText("Failed")
                      self._last_message_timestamp.setStyleSheet("""
                          QLabel {
                              background-color: #F44336;
                              color: white;
                              font-size: 11px;
                              border-radius: 8px;
                              padding: 2px 6px;
                          }
                      """)

          def _receive_message(self, msg_pmt):
              """
              Handler for 'in_msg' port. Extracts string and posts it to GUI thread
              via _poster.sig so _display_incoming runs in Qt thread.
              """
              try:
                  if pmt.is_symbol(msg_pmt) or pmt.is_string(msg_pmt):
                      s = pmt.symbol_to_string(msg_pmt)
                  else:
                      py = pmt.to_python(msg_pmt)
                      s = str(py)
              except Exception:
                  s = "<unreadable message>"

              # Post to GUI-thread handler
              try:
                  self._poster.sig.emit(s)
              except Exception:
                  # If signal emit fails for any reason, try direct call in case we're already in Qt thread
                  try:
                      self._display_incoming(s)
                  except Exception:
                      print("[messenger_gui] failed to deliver incoming message to GUI:", s)

          def _display_incoming(self, full_msg):
              """
              Build incoming bubble (left aligned). full_msg expected in "addr:body" format.
              """
              # try to split "addr:body"
              if ":" in full_msg:
                  addr, body = full_msg.split(":", 1)
                  display_text = f"{body}"
                  header_text = f"{addr}"
              else:
                  display_text = full_msg
                  header_text = ""

              container = QtWidgets.QWidget()
              vbox = QtWidgets.QVBoxLayout()
              vbox.setContentsMargins(0, 0, 0, 0)
              vbox.setSpacing(4)

              scroll = QtWidgets.QScrollArea()
              scroll.setWidgetResizable(True)
              scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)
              scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              scroll.setFrameShape(QtWidgets.QFrame.NoFrame)
              scroll.setStyleSheet("background: transparent; border: none;")

              bubble = QtWidgets.QLabel(display_text)
              bubble.setWordWrap(False)
              bubble.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              bubble.setStyleSheet("""
                  QLabel {
                      background-color: qlineargradient(x1:0,y1:0,x2:1,y2:1, stop:0 #E1F5FE, stop:1 #B3E5FC);
                      color: #0B2545;
                      border-radius: 12px;
                      padding: 8px 12px;
                      font-size: 14px;
                  }
              """)

              # small header with sender address (optional)
              if header_text:
                  header = QtWidgets.QLabel(header_text)
                  header.setStyleSheet("font-size: 11px; color: #1565C0;")
                  header.setAlignment(QtCore.Qt.AlignLeft)
                  vbox.addWidget(header, alignment=QtCore.Qt.AlignLeft)

              scroll.setWidget(bubble)
              scroll.setMinimumWidth(160)
              scroll.setMaximumWidth(520)

              vbox.addWidget(scroll, alignment=QtCore.Qt.AlignLeft)

              # incoming messages do not have delivery timestamp pill (feedback relates to outgoing)
              container.setLayout(vbox)
              container.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Fixed)

              self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignLeft)

              # Update layout and scroll to bottom
              bubble.adjustSize()
              scroll.adjustSize()
              container.adjustSize()
              self.chat_container.adjustSize()
              QtWidgets.QApplication.processEvents()
              QtCore.QTimer.singleShot(20, lambda: self.scroll_area.verticalScrollBar().setValue(
                  self.scroll_area.verticalScrollBar().maximum()
              ))
    bg_image: r"C:\Users\Oshan\Desktop\message.jpg"
    comment: GUI
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header Stream
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload Stream
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,1
    name: '"User 1 RX Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,1,1,1
    name: '"User 1 RX Synced Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: user1_freq
    gain: '50'
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: user2_freq
    gain: '30.0'
    samp_rate: samp_rate*2
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: to_user_2
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ACK
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: to_user_2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ACK
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_repack_bits_bb_1_0, '0', virtual_sink_1, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0_0, '0']
- [epy_block_0_0, feedback, epy_block_0_1, feedback]
- [epy_block_0_0, msg_out, epy_block_0_1, in_msg]
- [epy_block_0_0, pdu_out, digital_protocol_formatter_async_0, in]
- [epy_block_0_1, out, epy_block_0_0, msg_in]
- [epy_block_0_1, sync_cmd, epy_block_0_0, sync_cmd]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_0_0, pdu_in]
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [soapy_bladerf_source_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_1, '0', digital_symbol_sync_xx_0_0, '0']
- [virtual_source_1, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2, '0', pdu_tagged_stream_to_pdu_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
