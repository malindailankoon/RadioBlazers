options:
  parameters:
    author: malindatemp
    generate_options: qt_gui
    id: channel
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_1_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '32'
    sps: '4'
  states: {}
- name: digital_linear_equalizer_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '32'
    sps: '4'
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_1_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    NumberOfRetransmissions: '10'
    PropegationTime: '0.5'
    TransmissionTime: '0.2'
    UiFeedbackPort: '''tcp://127.0.0.1:5557'''
    UiMsgOutPort: '''tcp://127.0.0.1:5556'''
    _source_code: "\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport zmq\nimport threading\nimport queue\nimport time\nimport random\n\ndef byte_list_to_bitstring(int_arr):\n    return ''.join(f'{b:08b}' for b in int_arr)\n\ndef bit_string_to_byte_list(bits):\n    if len(bits) % 8 != 0:\n        raise ValueError(\"length not multiple of 8\")\n    return [int(bits[i:i+8], 2) for i in range(0, len(bits), 8)]\n\ndef msg_string_to_bitstring(msg_str):\n    bits = ''.join(f'{b:08b}' for b in msg_str.encode('utf-8'))\n    return bits\n\ndef bitstring_to_text(bits, encoding='utf-8'):\n    if len(bits) % 8 != 0:\n        raise ValueError(\"Bitstring length must be a multiple of 8\")\n    data = bytes(int(bits[i:i+8], 2) for i in range(0, len(bits), 8))\n    return data.decode(encoding)\n\nclass blk(gr.basic_block):  \n\n    def __init__(self, UiMsgOutPort='tcp://127.0.0.1:5556',\n                 UiFeedbackPort='tcp://127.0.0.1:5557',\n                 NumberOfRetransmissions=10,\n                 PropegationTime=0.5,\n                 TransmissionTime=0.2):  \n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Base_Station_Processor',   \n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.number_of_retransmissions = NumberOfRetransmissions\n        self.propegation_time = PropegationTime\n        self.transmission_time = TransmissionTime\n        self.UiFeedbackPort = UiFeedbackPort\n        self.UiMsgOutPort = UiMsgOutPort\n        \n\n\n        # ui sockets\n        self.context = zmq.Context.instance()\n\n        self.feedback_push_sock = self.context.socket(zmq.PUSH)\n        try:\n            self.feedback_push_sock.bind(self.UiFeedbackPort)\n        except Exception as e:\n            print(f\"custom_error: cant connect to socket: {e}\")\n\n        self.msg_to_ui_sock = self.context.socket(zmq.PUSH)\n        try:\n            self.msg_to_ui_sock.bind(self.UiMsgOutPort)\n        except Exception as e:\n            print(f\"custom_error: cant connect to socket: {e}\")\n        \n\n        \n        \n        # types\n        self.pkt_data = '00'\n        self.pkt_ack = '11'\n\n        # my address\n        self.my_address = '00'\n\n        # user node addresses\n        self.addrs = {\"User 1\": '01', \"User 2\": '10', \"User 3\": '11'}\n        self.users = {'01': 'user1', '10': 'user2', '11': 'user3'}\n\n        # for ack purposes\n        self.ack_received = False # the TX will know that an ack was received using this variable, then it reads the received_seq_number\n        self.received_ack_seq_number = 0\n        self.current_receiver = '' # use this for debug purposes \n\n        \n\n        # defining ports\n        self.message_port_register_in(pmt.intern('Msg_in'))\n        # self.message_port_register_out(pmt.intern('Msg_out'))\n        # self.message_port_register_out(pmt.intern('feedback'))\n        self.message_port_register_out(pmt.intern('Pkt_out'))\n        self.message_port_register_in(pmt.intern('Pkt_in'))\n\n        self.set_msg_handler(pmt.intern('Pkt_in'), self.inbound_pdu_handler)\n        self.set_msg_handler(pmt.intern('Msg_in'), self.inbound_msg_handler)\n\n        \n        # setting up threads\n        self._stop = threading.Event()\n        self.lock = threading.Lock()\n\n        self.inbound_pkt_buffer = queue.Queue() # holds byte arrays\n        self.rx_thread = threading.Thread(target=self.rx_handler)\n\n        self.inbound_msg_buffer = queue.Queue()\n        self.tx_thread = threading.Thread(target=self.tx_handler)\n        \n\n        self.rx_thread.start()\n        self.tx_thread.start()\n    \n    \n\n    def create_packet(self, tpe, dest_addr, src_addr, seq_no, payload=\"\"):\n        packet_str = tpe + dest_addr + src_addr + seq_no + payload\n        return packet_str\n    \n    def transmit(self, pkt_string):\n        try:\n            int_arr = bit_string_to_byte_list(pkt_string)\n            vec = pmt.init_u8vector(len(int_arr), int_arr)\n            pdu = pmt.cons(pmt.PMT_NIL, vec)\n\n            self.message_port_pub(pmt.intern('Pkt_out'), pdu)\n        except Exception as e:\n            print(f\"Custom_error: Error transmitting packet: {e}\")\n\n\n    def rx_handler(self):\n        while not self._stop.is_set():\n            # assuming the packet is a uint\n            try:\n                pkt_bytes = self.inbound_pkt_buffer.get(timeout=0.1)\n            except queue.Empty:\n                continue\n            \n            pkt_bitstring = byte_list_to_bitstring(pkt_bytes)\n\n            pkt_type = pkt_bitstring[:2]\n            pkt_dest_addr = pkt_bitstring[2:4]\n            pkt_src_addr = pkt_bitstring[4:6]\n            pkt_seq_num = pkt_bitstring[6:8]\n            pkt_payload = pkt_bitstring[8:]\n\n            seq_num_int = int(pkt_seq_num, 2)\n\n\n            if (pkt_type == self.pkt_data): # the pkt received is a data packet\n                if (pkt_dest_addr == self.my_address):\n                    new_seq_num = f\"{(seq_num_int+1):02b}\"\n                    pkt_str = self.create_packet(self.pkt_ack, pkt_src_addr, pkt_dest_addr, new_seq_num)\n                    \n                    with self.lock:\n                        self.transmit(pkt_str)\n\n                    \n                    payload_text = bitstring_to_text(pkt_payload)\n                    \n                    text = pkt_src_addr + \":\" + payload_text\n\n                    # creating the pdu to send to UI\n                    # text_b = text.encode(\"utf-8\")\n                    # pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(text_b), bytearray(text_b)))\n                    # self.message_port_pub(pmt.intern('Msg_out'), pdu)\n\n                    # send message to ui\n                    self.msg_to_ui_sock.send_string(text)\n\n\n                else:\n                    # the packet is not meant for me\n                    continue\n            elif (pkt_type == self.pkt_ack): # the pkt received is a ack packet\n                if (pkt_dest_addr == self.my_address):\n                    self.current_receiver = pkt_src_addr\n                    self.received_ack_seq_number = pkt_seq_num\n                    self.ack_received = True\n                    if (pkt_payload != ''):\n                        raise ValueError(f\"malinda's custom error: an acknowledgement packet cannot have a payload\")\n                else:\n                    # the packet is not meant for me\n                    # POSSIBLE ERROR PLACE, PLEASE CHECK WHEN TESING\n                    continue\n            else:\n                raise ValueError(f\"malinda's custom error: {pkt_type} is not a valid type\")\n    \n\n    def tx_handler(self):\n        while not self._stop.is_set():\n            try:\n                try:\n                    msg_bytes = self.inbound_msg_buffer.get(timeout=0.1)\n                except queue.Empty:\n                    continue\n            \n                msg_string = msg_bytes.decode(\"utf-8\", errors=\"strict\")\n                dest_addr, text = msg_string.split(\":\")\n\n\n                msg_bitstring = msg_string_to_bitstring(text)\n                current_seq_num = 0\n                seq_num_str = f\"{current_seq_num:02b}\"\n                current_pkt = self.create_packet(self.pkt_data, dest_addr, self.my_address, seq_num_str, msg_bitstring)\n\n                K = 0\n                success = False\n                abort = False\n                while (success != True and abort != True):\n                    with self.lock:\n                        self.transmit(current_pkt)\n                    \n                    time.sleep(2 * self.propegation_time)\n\n                    if (self.ack_received == True):\n                        with self.lock:\n                            self.ack_received = False\n                        if (self.received_ack_seq_number > current_seq_num):\n                            if (self.current_receiver != dest_addr):\n                                raise ValueError(\"malinda's custom error: the base got an unintended ack packet!\")\n                            \n                            # send feedback to ui\n                            self.feedback_push_sock.send_string(\"True\")\n                            success = True\n                            continue\n                    \n                    K += 1\n                    if (K > self.number_of_retransmissions):\n                        self.feedback_push_sock.send_string(\"False\")\n                        abort = True\n                        continue\n\n                    R = random.getrandbits(K)\n\n                    Tb = R * self.propegation_time\n                    time.sleep(Tb)\n                    continue\n\n\n            \n            except Exception as e:\n                print(f\"[custom_handler TX handler error: {e}\")\n            \n                \n\n\n    def inbound_msg_handler(self, pdu):\n        try:\n            if pmt.is_pair(pdu):\n                data = pmt.cdr(pdu)\n\n                msg_bytes = bytes(pmt.u8vector_elements(data))\n                self.inbound_msg_buffer.put(msg_bytes)\n        \n        except Exception as e:\n            print(f\"[custom_error: Error handling Msg_in: {e}\")\n    \n    def inbound_pdu_handler(self, pdu):\n        try:\n            if pmt.is_pair(pdu):\n                data = pmt.cdr(pdu)\n\n                rx_bytes = bytes(pmt.u8vector_elements(data))\n                self.inbound_pkt_buffer.put(rx_bytes)\n\n        \n        except Exception as e:\n            print(f\"[custom_error: Error handling pdu_in: {e}\")\n    \n\n    def on_close(self):\n        self._stop.set()\n        if self.rx_thread.is_alive():\n            self.rx_thread.join()\n\n\n\n\n"
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    NumberOfRetransmissions: '10'
    PropegationTime: '0.5'
    TransmissionTime: '0.2'
    UiFeedbackPort: '''tcp://127.0.0.1:6667'''
    UiMsgOutPort: '''tcp://127.0.0.1:6556'''
    _source_code: "\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport zmq\nimport threading\nimport queue\nimport time\nimport random\n\ndef byte_list_to_bitstring(int_arr):\n    return ''.join(f'{b:08b}' for b in int_arr)\n\ndef bit_string_to_byte_list(bits):\n    if len(bits) % 8 != 0:\n        raise ValueError(\"length not multiple of 8\")\n    return [int(bits[i:i+8], 2) for i in range(0, len(bits), 8)]\n\ndef msg_string_to_bitstring(msg_str):\n    bits = ''.join(f'{b:08b}' for b in msg_str.encode('utf-8'))\n    return bits\n\ndef bitstring_to_text(bits, encoding='utf-8'):\n    if len(bits) % 8 != 0:\n        raise ValueError(\"Bitstring length must be a multiple of 8\")\n    data = bytes(int(bits[i:i+8], 2) for i in range(0, len(bits), 8))\n    return data.decode(encoding)\n\n\n\nclass blk(gr.basic_block):\n\n    def __init__(self, UiMsgOutPort='tcp://127.0.0.1:6556',\n                 UiFeedbackPort='tcp://127.0.0.1:6557',\n                 NumberOfRetransmissions=10,\n                 PropegationTime=0.5,\n                 TransmissionTime=0.2):\n        gr.sync_block.__init__(\n            self,\n            name='User_side_Processor', \n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.UiMsgOutPort = UiMsgOutPort\n        self.UiFeedbackPort = UiFeedbackPort\n        self.NumberOfRetransmissions = NumberOfRetransmissions\n        self.PropegationTime = PropegationTime\n        self.TransmissionTime = TransmissionTime\n\n\n        # ui sockets\n        self.context = zmq.Context.instance()\n\n        self.feedback_push_sock = self.context.socket(zmq.PUSH)\n        try:\n            self.feedback_push_sock.bind(self.UiFeedbackPort)\n        except Exception as e:\n            print(f\"custom_error: cant connect to socket: {e}\")\n        \n\n        self.msg_to_ui_sock = self.context.socket(zmq.PUSH)\n        try:\n            self.msg_to_ui_sock.bind(self.UiMsgOutPort)\n        except Exception as e:\n            print(f\"custom_error: cant connect to socket: {e}\")\n        \n\n        # types\n        self.pkt_data = '00'\n        self.pkt_ack = '11'\n\n        # my address\n        self.my_address = '01'\n\n        # base address\n        self.base_address = '00'\n\n\n        # for ack purposes\n        self.ack_received = False # the TX will know that an ack was received using this variable, then it reads the received_seq_number\n        self.received_ack_seq_number = 0\n        self.current_receiver = '' # use this for debug purposes \n\n\n        # defining ports\n        self.message_port_register_in(pmt.intern('Msg_in'))\n        self.message_port_register_out(pmt.intern('Pkt_out'))\n        self.message_port_register_in(pmt.intern('Pkt_in'))\n\n        self.set_msg_handler(pmt.intern('Pkt_in'), self.inbound_pdu_handler)\n        self.set_msg_handler(pmt.intern('Msg_in'), self.inbound_msg_handler)\n\n\n        # setting up threads\n        self._stop = threading.Event()\n        self.lock = threading.Lock()\n\n        self.inbound_pkt_buffer = queue.Queue() # holds byte arrays\n        self.rx_thread = threading.Thread(target=self.rx_handler)\n\n        self.inbound_msg_buffer = queue.Queue()\n        self.tx_thread = threading.Thread(target=self.tx_handler)\n\n        self.rx_thread.start()\n        self.tx_thread.start()\n    \n\n    def create_packet(self, tpe, dest_addr, src_addr, seq_no, payload=\"\"):\n        packet_str = tpe + dest_addr + src_addr + seq_no + payload\n        return packet_str\n    \n\n    def transmit(self, pkt_string):\n        try:\n            int_arr = bit_string_to_byte_list(pkt_string)\n            vec = pmt.init_u8vector(len(int_arr), int_arr)\n            pdu = pmt.cons(pmt.PMT_NIL, vec)\n\n            self.message_port_pub(pmt.intern('Pkt_out'), pdu)\n        except Exception as e:\n            print(f\"Custom_error: Error transmitting packet: {e}\")\n    \n\n    def rx_handler(self):\n        while not self._stop.is_set():\n            # assuming the packet is a uint\n            try:\n                pkt_bytes = self.inbound_pkt_buffer.get(timeout=0.1)\n            except queue.Empty:\n                continue\n            \n            pkt_bitstring = byte_list_to_bitstring(pkt_bytes)\n\n            pkt_type = pkt_bitstring[:2]\n            pkt_dest_addr = pkt_bitstring[2:4]\n            pkt_src_addr = pkt_bitstring[4:6]\n            pkt_seq_num = pkt_bitstring[6:8]\n            pkt_payload = pkt_bitstring[8:]\n\n            seq_num_int = int(pkt_seq_num, 2)\n\n\n            if (pkt_type == self.pkt_data): # the pkt received is a data packet\n                if (pkt_dest_addr == self.my_address):\n                    new_seq_num = f\"{(seq_num_int+1):02b}\"\n                    pkt_str = self.create_packet(self.pkt_ack, pkt_src_addr, pkt_dest_addr, new_seq_num)\n                    \n                    with self.lock:\n                        self.transmit(pkt_str)\n\n                    \n                    payload_text = bitstring_to_text(pkt_payload)\n                    \n                    # text = self.users[pkt_src_addr] + payload_text\n                    text = payload_text\n\n                    # creating the pdu to send to UI\n                    # text_b = text.encode(\"utf-8\")\n                    # pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(text_b), bytearray(text_b)))\n                    # self.message_port_pub(pmt.intern('Msg_out'), pdu)\n\n                    # send message to ui\n                    self.msg_to_ui_sock.send_string(text)\n\n\n                else:\n                    # the packet is not meant for me\n                    continue\n            elif (pkt_type == self.pkt_ack): # the pkt received is a ack packet\n                if (pkt_dest_addr == self.my_address):\n                    self.current_receiver = pkt_src_addr\n                    self.received_ack_seq_number = pkt_seq_num\n                    self.ack_received = True\n                    if (pkt_payload != ''):\n                        raise ValueError(f\"malinda's custom error: an acknowledgement packet cannot have a payload\")\n                else:\n                    # the packet is not meant for me\n                    # POSSIBLE ERROR PLACE, PLEASE CHECK WHEN TESING\n                    continue\n            else:\n                raise ValueError(f\"malinda's custom error: {pkt_type} is not a valid type\")\n    \n\n    def tx_handler(self):\n        while not self._stop.is_set():\n            try:\n                try:\n                    msg_bytes = self.inbound_msg_buffer.get(timeout=0.1)\n                except queue.Empty:\n                    continue\n            \n                msg_string = msg_bytes.decode(\"utf-8\", errors=\"strict\")\n                \n\n\n                msg_bitstring = msg_string_to_bitstring(msg_string)\n                current_seq_num = 0\n                seq_num_str = f\"{current_seq_num:02b}\"\n                current_pkt = self.create_packet(self.pkt_data, self.base_address, self.my_address, seq_num_str, msg_bitstring)\n\n                K = 0\n                success = False\n                abort = False\n                while (success != True and abort != True):\n                    with self.lock:\n                        self.transmit(current_pkt)\n                    \n                    time.sleep(2 * self.propegation_time)\n\n                    if (self.ack_received == True):\n                        with self.lock:\n                            self.ack_received = False\n                        if (self.received_ack_seq_number > current_seq_num):\n                            if (self.current_receiver != self.base_address):\n                                raise ValueError(\"malinda's custom error: the base got an unintended ack packet!\")\n                            \n                            # send feedback to ui\n                            self.feedback_push_sock.send_string(\"True\")\n                            success = True\n                            continue\n                    \n                    K += 1\n                    if (K > self.number_of_retransmissions):\n                        self.feedback_push_sock.send_string(\"False\")\n                        abort = True\n                        continue\n\n                    R = random.getrandbits(K)\n\n                    Tb = R * self.propegation_time\n                    time.sleep(Tb)\n                    continue\n\n            except Exception as e:\n                print(f\"[custom_handler TX handler error: {e}\")\n            \n                \n    def inbound_msg_handler(self, pdu):\n        try:\n            if pmt.is_pair(pdu):\n                data = pmt.cdr(pdu)\n\n                msg_bytes = bytes(pmt.u8vector_elements(data))\n                self.inbound_msg_buffer.put(msg_bytes)\n        \n        except Exception as e:\n            print(f\"[custom_error: Error handling Msg_in: {e}\")\n    \n\n    def inbound_pdu_handler(self, pdu):\n        try:\n            if pmt.is_pair(pdu):\n                data = pmt.cdr(pdu)\n\n                rx_bytes = bytes(pmt.u8vector_elements(data))\n                self.inbound_pkt_buffer.put(rx_bytes)\n\n        except Exception as e:\n            print(f\"[custom_error: Error handling pdu_in: {e}\")\n\n\n    def on_close(self):\n        self._stop.set()\n        if self.rx_thread.is_alive():\n            self.rx_thread.join()\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import threading
      import zmq
      import pmt
      from gnuradio import gr
      import json

      class blk(gr.basic_block):
          """
          ZMQ PULL -> GNU Radio PDU (meta=PMT_NIL, data=u8vector)
          Accepts raw bytes/strings from external senders without PMT serialization.
          """

          def __init__(self, endpoint='tcp://127.0.0.1:5555', bind=False, rcv_timeout_ms=100):
              gr.basic_block.__init__(self, name="pyzmq_pull", in_sig=[], out_sig=[])

              # Params (editable in GRC via block args if you expose them)
              self.endpoint = endpoint
              self.bind = bool(bind)
              self.rcv_timeout_ms = int(rcv_timeout_ms)

              # Message out port
              self.message_port_register_out(pmt.intern("out"))

              # ZMQ state
              self._ctx = None
              self._sock = None
              self._thread = None
              self._running = threading.Event()

          # Start/stop are the right places to spin threads/sockets in GNU Radio
          def start(self):
              self._ctx = zmq.Context.instance()
              self._sock = self._ctx.socket(zmq.PULL)

              # Tame shutdown and avoid hangs
              self._sock.setsockopt(zmq.LINGER, 0)
              self._sock.setsockopt(zmq.RCVTIMEO, self.rcv_timeout_ms)
              # Optional HWM if you want tighter buffering:
              # self._sock.setsockopt(zmq.RCVHWM, 100)

              if self.bind:
                  # Bind (listener)
                  self._sock.bind(self.endpoint)           # e.g., "tcp://*:5555"
              else:
                  # Connect (dialer)
                  self._sock.connect(self.endpoint)        # e.g., "tcp://127.0.0.1:5555"

              self._running.set()
              self._thread = threading.Thread(target=self._rx_loop, daemon=True)
              self._thread.start()
              return super().start()

          def stop(self):
              self._running.clear()
              try:
                  if self._thread:
                      self._thread.join(timeout=1.0)
              except Exception:
                  pass
              try:
                  if self._sock:
                      self._sock.close(0)
              except Exception:
                  pass
              # Don’t terminate the shared context; other blocks may use it
              self._ctx = None
              self._sock = None
              return super().stop()

          def _rx_loop(self):
              while self._running.is_set():
                  try:
                      # Receive one ZMQ frame (bytes). Works with send(), send_string(), send_json() etc.
                      frame = self._sock.recv()  # bytes; RCVTIMEO makes this return after timeout
                  except zmq.Again:
                      continue  # timeout, loop again
                  except Exception as e:
                      print("[pyzmq_pull] recv error:", e)
                      break

                  if not frame:
                      continue
                  
                  frame = list(frame)
                  print(frame)
                  u8 = pmt.init_u8vector(len(frame), frame)
                  pdu = pmt.cons(pmt.PMT_NIL, u8)
                  self.message_port_pub(pmt.intern("out"), pdu)
    bind: 'True'
    endpoint: '''tcp://127.0.0.1:5555'''
    rcv_timeout_ms: '100'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import threading
      import zmq
      import pmt
      from gnuradio import gr
      import json

      class blk(gr.basic_block):
          """
          ZMQ PULL -> GNU Radio PDU (meta=PMT_NIL, data=u8vector)
          Accepts raw bytes/strings from external senders without PMT serialization.
          """

          def __init__(self, endpoint='tcp://127.0.0.1:6665', bind=False, rcv_timeout_ms=100):
              gr.basic_block.__init__(self, name="pyzmq_pull", in_sig=[], out_sig=[])

              # Params (editable in GRC via block args if you expose them)
              self.endpoint = endpoint
              self.bind = bool(bind)
              self.rcv_timeout_ms = int(rcv_timeout_ms)

              # Message out port
              self.message_port_register_out(pmt.intern("out"))

              # ZMQ state
              self._ctx = None
              self._sock = None
              self._thread = None
              self._running = threading.Event()

          # Start/stop are the right places to spin threads/sockets in GNU Radio
          def start(self):
              self._ctx = zmq.Context.instance()
              self._sock = self._ctx.socket(zmq.PULL)

              # Tame shutdown and avoid hangs
              self._sock.setsockopt(zmq.LINGER, 0)
              self._sock.setsockopt(zmq.RCVTIMEO, self.rcv_timeout_ms)
              # Optional HWM if you want tighter buffering:
              # self._sock.setsockopt(zmq.RCVHWM, 100)

              if self.bind:
                  # Bind (listener)
                  self._sock.bind(self.endpoint)           # e.g., "tcp://*:5555"
              else:
                  # Connect (dialer)
                  self._sock.connect(self.endpoint)        # e.g., "tcp://127.0.0.1:5555"

              self._running.set()
              self._thread = threading.Thread(target=self._rx_loop, daemon=True)
              self._thread.start()
              return super().start()

          def stop(self):
              self._running.clear()
              try:
                  if self._thread:
                      self._thread.join(timeout=1.0)
              except Exception:
                  pass
              try:
                  if self._sock:
                      self._sock.close(0)
              except Exception:
                  pass
              # Don’t terminate the shared context; other blocks may use it
              self._ctx = None
              self._sock = None
              return super().stop()

          def _rx_loop(self):
              while self._running.is_set():
                  try:
                      # Receive one ZMQ frame (bytes). Works with send(), send_string(), send_json() etc.
                      frame = self._sock.recv()  # bytes; RCVTIMEO makes this return after timeout
                  except zmq.Again:
                      continue  # timeout, loop again
                  except Exception as e:
                      print("[pyzmq_pull] recv error:", e)
                      break

                  if not frame:
                      continue
                  
                  # message = frame.decode("utf-8")
                  frame = list(frame)
                  print(frame)
                  u8 = pmt.init_u8vector(len(frame), frame)
                  pdu = pmt.cons(pmt.PMT_NIL, u8)
                  self.message_port_pub(pmt.intern("out"), pdu)
    bind: 'True'
    endpoint: '''tcp://127.0.0.1:6665'''
    rcv_timeout_ms: '100'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: base_to_user
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: user_to_base
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: base_to_user
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: user_to_base
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49202
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49204
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [channels_channel_model_0, '0', zeromq_pub_sink_0_0_0, '0']
- [channels_channel_model_0_0, '0', virtual_sink_1, '0']
- [channels_channel_model_0_0, '0', zeromq_pub_sink_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_1, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_1_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc_append_0_0, out, digital_protocol_formatter_async_0_0, in]
- [digital_crc_check_0, ok, epy_block_0_0, Pkt_in]
- [digital_crc_check_0_0, ok, epy_block_0, Pkt_in]
- [digital_diff_decoder_bb_0_1, '0', digital_map_bb_0_1, '0']
- [digital_diff_decoder_bb_0_1_0, '0', digital_map_bb_0_1_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_1_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_linear_equalizer_0_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_1, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_1_0, pdus]
- [epy_block_0, Pkt_out, digital_crc_append_0, in]
- [epy_block_0_0, Pkt_out, digital_crc_append_0_0, in]
- [epy_block_1, out, epy_block_0, Msg_in]
- [epy_block_1_0, out, epy_block_0_0, Msg_in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_1_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_check_0, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0_0, in]
- [virtual_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_1, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [zeromq_sub_source_0_0, '0', channels_channel_model_0_0, '0']
- [zeromq_sub_source_0_0_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
