options:
  parameters:
    author: malinda
    generate_options: qt_gui
    id: combined_go_back_n
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Set Bandwidth
    value: '.5'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '11100001010110101110100010010011'
    bps: '1'
    threshold: '1'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: spr
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.01'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_linear_equalizer_0_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import pmt
      from datetime import datetime

      class WallpaperScrollArea(QtWidgets.QScrollArea):
          def __init__(self, bg_image="", parent=None):
              super().__init__(parent)
              self.setWidgetResizable(True)
              self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None

          def paintEvent(self, event):
              if self.bg_pixmap:
                  painter = QtGui.QPainter(self.viewport())
                  painter.drawPixmap(self.viewport().rect(), self.bg_pixmap)
              super().paintEvent(event)


      class _GuiPoster(QtCore.QObject):
          """Helper QObject to post strings into the Qt thread safely."""
          sig = QtCore.pyqtSignal(str)  # emits text payload

          def __init__(self):
              super().__init__()


      class messenger_gui(gr.basic_block):
          """
          WhatsApp-style Messenger GUI (GNU Radio embedded block).
          - Outgoing messages: published on message port "out" with address prepended as "addr:body"
          - Feedback port "feedback": updates delivery timestamp / failed status
          - Incoming messages: received on port "in_msg" (same format "addr:body") and displayed
            on the left in a different color.
          """

          def __init__(self, bg_image=""):
              gr.basic_block.__init__(
                  self,
                  name="Messenger GUI",
                  in_sig=None,
                  out_sig=None,
              )

              # Message ports
              self.message_port_register_out(pmt.intern("out"))    # outgoing messages
              self.message_port_register_in(pmt.intern("feedback"))# delivery feedback
              self.message_port_register_in(pmt.intern("in_msg"))  # incoming messages from remote/devices

              # Bind handlers
              self.set_msg_handler(pmt.intern("feedback"), self._process_feedback)
              self.set_msg_handler(pmt.intern("in_msg"), self._receive_message)

              # Poster used to safely move messages to GUI thread
              self._poster = _GuiPoster()
              self._poster.sig.connect(self._display_incoming)  # connect to GUI-thread handler

              # Qt Application
              self.app = QtWidgets.QApplication.instance()
              if self.app is None:
                  self.app = QtWidgets.QApplication(sys.argv)

              # Main window
              self.qt_widget = QtWidgets.QWidget()
              self.qt_widget.setWindowTitle("Messenger GUI User 1")
              self.qt_widget.resize(640, 560)

              main_layout = QtWidgets.QVBoxLayout()
              main_layout.setContentsMargins(8, 8, 8, 8)
              main_layout.setSpacing(6)
              self.qt_widget.setLayout(main_layout)

              # Address selection bar
              addr_layout = QtWidgets.QHBoxLayout()
              addr_label = QtWidgets.QLabel("To:")
              addr_label.setStyleSheet("font-size: 18px; font-weight: bold;")
              addr_layout.addWidget(addr_label)

              self.addr_box = QtWidgets.QComboBox()
              self.addr_box.addItems([str(i) for i in range(1, 11)])  # 1..10 default
              self.addr_box.setFixedWidth(100)
              self.addr_box.setStyleSheet("font-size: 16px; padding: 4px;")
              addr_layout.addWidget(self.addr_box)
              addr_layout.addStretch()

              main_layout.addLayout(addr_layout)

              # Scroll area with background
              self.scroll_area = WallpaperScrollArea(bg_image=bg_image)
              self.scroll_area.setStyleSheet("border: none;")
              self.scroll_area.setWidgetResizable(True)
              main_layout.addWidget(self.scroll_area, stretch=1)

              # Chat container (vertical list of message widgets)
              self.chat_container = QtWidgets.QWidget()
              self.chat_layout = QtWidgets.QVBoxLayout()
              self.chat_layout.setAlignment(QtCore.Qt.AlignTop)
              self.chat_layout.setSpacing(10)
              self.chat_container.setLayout(self.chat_layout)
              self.chat_container.setStyleSheet("background: transparent;")
              self.scroll_area.setWidget(self.chat_container)

              # Input area (text entry + send)
              input_layout = QtWidgets.QHBoxLayout()
              self.input_box = QtWidgets.QLineEdit()
              self.input_box.setPlaceholderText("Type a message...")
              self.input_box.setMinimumHeight(40)
              self.input_box.setStyleSheet("""
                  QLineEdit {
                      border-radius: 12px;
                      padding: 8px;
                      background-color: rgba(255,255,255,0.95);
                      font-size: 16px;
                  }
              """)
              self.send_button = QtWidgets.QPushButton("Send")
              self.send_button.setMinimumHeight(40)
              self.send_button.setStyleSheet("""
                  QPushButton {
                      background-color: #4CAF50;
                      color: white;
                      border-radius: 10px;
                      padding: 8px 16px;
                      font-weight: bold;
                      font-size: 16px;
                  }
                  QPushButton:hover { background-color: #45a049; }
              """)
              input_layout.addWidget(self.input_box, stretch=1)
              input_layout.addWidget(self.send_button, stretch=0)
              main_layout.addLayout(input_layout)

              # Connect GUI signals
              self.send_button.clicked.connect(self.send_message)
              self.input_box.returnPressed.connect(self.send_message)

              # Track last sent message timestamp widget (simple approach)
              # If you want per-message tracking, change to a list/map of widgets per message id.
              self._last_message_timestamp = None

              # show window
              self.qt_widget.show()

          def send_message(self):
              """Called from GUI thread when user presses Send or Enter."""
              text = self.input_box.text().strip()
              if not text:
                  return

              addr = self.addr_box.currentText().strip()
              full_msg = f"{addr}:{text}"

              # Publish as PMT symbol/string on 'out' port
              try:
                  self.message_port_pub(pmt.intern("out"), pmt.intern(full_msg))
              except Exception:
                  # fallback to generic intern
                  self.message_port_pub(pmt.intern("out"), pmt.intern(full_msg))

              # Build outgoing bubble (right side)
              container = QtWidgets.QWidget()
              vbox = QtWidgets.QVBoxLayout()
              vbox.setContentsMargins(0, 0, 0, 0)
              vbox.setSpacing(4)

              # Scrollable area for long messages
              scroll = QtWidgets.QScrollArea()
              scroll.setWidgetResizable(True)
              scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)
              scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              scroll.setFrameShape(QtWidgets.QFrame.NoFrame)
              scroll.setStyleSheet("background: transparent; border: none;")

              bubble = QtWidgets.QLabel(text)  # show only body (user-friendly)
              bubble.setWordWrap(False)
              bubble.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              bubble.setStyleSheet("""
                  QLabel {
                      background-color: qlineargradient(x1:0,y1:0,x2:1,y2:1, stop:0 #4CAF50, stop:1 #66BB6A);
                      color: white;
                      border-radius: 12px;
                      padding: 8px 12px;
                      font-size: 14px;
                  }
              """)
              # shadow
              effect = QtWidgets.QGraphicsDropShadowEffect()
              effect.setBlurRadius(6)
              effect.setXOffset(2)
              effect.setYOffset(2)
              effect.setColor(QtGui.QColor(0, 0, 0, 80))
              bubble.setGraphicsEffect(effect)

              scroll.setWidget(bubble)
              scroll.setMinimumWidth(160)
              scroll.setMaximumWidth(520)

              # Timestamp pill (initially 'Sending...')
              timestamp = QtWidgets.QLabel("Sending...")
              timestamp.setStyleSheet("""
                  QLabel {
                      background-color: #2196F3;
                      color: white;
                      font-size: 11px;
                      border-radius: 8px;
                      padding: 2px 6px;
                  }
              """)
              timestamp.setAlignment(QtCore.Qt.AlignRight)
              timestamp.setSizePolicy(QtWidgets.QSizePolicy.Fixed, QtWidgets.QSizePolicy.Fixed)

              vbox.addWidget(scroll, alignment=QtCore.Qt.AlignRight)
              vbox.addWidget(timestamp, alignment=QtCore.Qt.AlignRight)
              container.setLayout(vbox)
              container.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Fixed)

              # Add to chat layout (right aligned)
              self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignRight)

              # Force layout update and scroll to bottom
              bubble.adjustSize()
              scroll.adjustSize()
              container.adjustSize()
              self.chat_container.adjustSize()
              QtWidgets.QApplication.processEvents()
              QtCore.QTimer.singleShot(20, lambda: self.scroll_area.verticalScrollBar().setValue(
                  self.scroll_area.verticalScrollBar().maximum()
              ))

              # Clear input and store timestamp widget for feedback updates
              self.input_box.clear()
              self._last_message_timestamp = timestamp

          def _process_feedback(self, msg_pmt):
              """
              Handler for 'feedback' port. Expected feedback values:
                - "TRUE" => show delivery time
                - "FALSE" => show 'Failed'
              """
              try:
                  if pmt.is_symbol(msg_pmt) or pmt.is_string(msg_pmt):
                      fb = pmt.symbol_to_string(msg_pmt)
                  else:
                      py = pmt.to_python(msg_pmt)
                      fb = str(py)
              except Exception:
                  fb = "<unreadable feedback>"

              print(fb)
              # Update last timestamp widget if available (simple single-last approach)
              if self._last_message_timestamp:
                  if fb == "TRUE":
                      self._last_message_timestamp.setText(datetime.now().strftime("%H:%M:%S"))
                      self._last_message_timestamp.setStyleSheet("""
                          QLabel {
                              background-color: #2196F3;
                              color: white;
                              font-size: 11px;
                              border-radius: 8px;
                              padding: 2px 6px;
                          }
                      """)
                  elif fb == "FALSE":
                      self._last_message_timestamp.setText("Failed")
                      self._last_message_timestamp.setStyleSheet("""
                          QLabel {
                              background-color: #F44336;
                              color: white;
                              font-size: 11px;
                              border-radius: 8px;
                              padding: 2px 6px;
                          }
                      """)

          def _receive_message(self, msg_pmt):
              """
              Handler for 'in_msg' port. Extracts string and posts it to GUI thread
              via _poster.sig so _display_incoming runs in Qt thread.
              """
              try:
                  if pmt.is_symbol(msg_pmt) or pmt.is_string(msg_pmt):
                      s = pmt.symbol_to_string(msg_pmt)
                  else:
                      py = pmt.to_python(msg_pmt)
                      s = str(py)
              except Exception:
                  s = "<unreadable message>"

              # Post to GUI-thread handler
              try:
                  self._poster.sig.emit(s)
              except Exception:
                  # If signal emit fails for any reason, try direct call in case we're already in Qt thread
                  try:
                      self._display_incoming(s)
                  except Exception:
                      print("[messenger_gui] failed to deliver incoming message to GUI:", s)

          def _display_incoming(self, full_msg):
              """
              Build incoming bubble (left aligned). full_msg expected in "addr:body" format.
              """
              # try to split "addr:body"
              if ":" in full_msg:
                  addr, body = full_msg.split(":", 1)
                  display_text = f"{body}"
                  header_text = f"{addr}"
              else:
                  display_text = full_msg
                  header_text = ""

              container = QtWidgets.QWidget()
              vbox = QtWidgets.QVBoxLayout()
              vbox.setContentsMargins(0, 0, 0, 0)
              vbox.setSpacing(4)

              scroll = QtWidgets.QScrollArea()
              scroll.setWidgetResizable(True)
              scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)
              scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              scroll.setFrameShape(QtWidgets.QFrame.NoFrame)
              scroll.setStyleSheet("background: transparent; border: none;")

              bubble = QtWidgets.QLabel(display_text)
              bubble.setWordWrap(False)
              bubble.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              bubble.setStyleSheet("""
                  QLabel {
                      background-color: qlineargradient(x1:0,y1:0,x2:1,y2:1, stop:0 #E1F5FE, stop:1 #B3E5FC);
                      color: #0B2545;
                      border-radius: 12px;
                      padding: 8px 12px;
                      font-size: 14px;
                  }
              """)

              # small header with sender address (optional)
              if header_text:
                  header = QtWidgets.QLabel(header_text)
                  header.setStyleSheet("font-size: 11px; color: #1565C0;")
                  header.setAlignment(QtCore.Qt.AlignLeft)
                  vbox.addWidget(header, alignment=QtCore.Qt.AlignLeft)

              scroll.setWidget(bubble)
              scroll.setMinimumWidth(160)
              scroll.setMaximumWidth(520)

              vbox.addWidget(scroll, alignment=QtCore.Qt.AlignLeft)

              # incoming messages do not have delivery timestamp pill (feedback relates to outgoing)
              container.setLayout(vbox)
              container.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Fixed)

              self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignLeft)

              # Update layout and scroll to bottom
              bubble.adjustSize()
              scroll.adjustSize()
              container.adjustSize()
              self.chat_container.adjustSize()
              QtWidgets.QApplication.processEvents()
              QtCore.QTimer.singleShot(20, lambda: self.scroll_area.verticalScrollBar().setValue(
                  self.scroll_area.verticalScrollBar().maximum()
              ))
    bg_image: r"C:\Users\Oshan\Desktop\message.jpg"
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import pmt
      from datetime import datetime

      class WallpaperScrollArea(QtWidgets.QScrollArea):
          def __init__(self, bg_image="", parent=None):
              super().__init__(parent)
              self.setWidgetResizable(True)
              self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None

          def paintEvent(self, event):
              if self.bg_pixmap:
                  painter = QtGui.QPainter(self.viewport())
                  painter.drawPixmap(self.viewport().rect(), self.bg_pixmap)
              super().paintEvent(event)


      class _GuiPoster(QtCore.QObject):
          """Helper QObject to post strings into the Qt thread safely."""
          sig = QtCore.pyqtSignal(str)  # emits text payload

          def __init__(self):
              super().__init__()


      class messenger_gui(gr.basic_block):
          """
          WhatsApp-style Messenger GUI (GNU Radio embedded block).
          - Outgoing messages: published on message port "out" with address prepended as "addr:body"
          - Feedback port "feedback": updates delivery timestamp / failed status
          - Incoming messages: received on port "in_msg" (same format "addr:body") and displayed
            on the left in a different color.
          """

          def __init__(self, bg_image=""):
              gr.basic_block.__init__(
                  self,
                  name="Messenger GUI",
                  in_sig=None,
                  out_sig=None,
              )

              # Message ports
              self.message_port_register_out(pmt.intern("out"))    # outgoing messages
              self.message_port_register_in(pmt.intern("feedback"))# delivery feedback
              self.message_port_register_in(pmt.intern("in_msg"))  # incoming messages from remote/devices

              # Bind handlers
              self.set_msg_handler(pmt.intern("feedback"), self._process_feedback)
              self.set_msg_handler(pmt.intern("in_msg"), self._receive_message)

              # Poster used to safely move messages to GUI thread
              self._poster = _GuiPoster()
              self._poster.sig.connect(self._display_incoming)  # connect to GUI-thread handler

              # Qt Application
              self.app = QtWidgets.QApplication.instance()
              if self.app is None:
                  self.app = QtWidgets.QApplication(sys.argv)

              # Main window
              self.qt_widget = QtWidgets.QWidget()
              self.qt_widget.setWindowTitle("Messenger GUI User 2")
              self.qt_widget.resize(640, 560)

              main_layout = QtWidgets.QVBoxLayout()
              main_layout.setContentsMargins(8, 8, 8, 8)
              main_layout.setSpacing(6)
              self.qt_widget.setLayout(main_layout)

              # Address selection bar
              addr_layout = QtWidgets.QHBoxLayout()
              addr_label = QtWidgets.QLabel("To:")
              addr_label.setStyleSheet("font-size: 18px; font-weight: bold;")
              addr_layout.addWidget(addr_label)

              self.addr_box = QtWidgets.QComboBox()
              self.addr_box.addItems([str(i) for i in range(1, 11)])  # 1..10 default
              self.addr_box.setFixedWidth(100)
              self.addr_box.setStyleSheet("font-size: 16px; padding: 4px;")
              addr_layout.addWidget(self.addr_box)
              addr_layout.addStretch()

              main_layout.addLayout(addr_layout)

              # Scroll area with background
              self.scroll_area = WallpaperScrollArea(bg_image=bg_image)
              self.scroll_area.setStyleSheet("border: none;")
              self.scroll_area.setWidgetResizable(True)
              main_layout.addWidget(self.scroll_area, stretch=1)

              # Chat container (vertical list of message widgets)
              self.chat_container = QtWidgets.QWidget()
              self.chat_layout = QtWidgets.QVBoxLayout()
              self.chat_layout.setAlignment(QtCore.Qt.AlignTop)
              self.chat_layout.setSpacing(10)
              self.chat_container.setLayout(self.chat_layout)
              self.chat_container.setStyleSheet("background: transparent;")
              self.scroll_area.setWidget(self.chat_container)

              # Input area (text entry + send)
              input_layout = QtWidgets.QHBoxLayout()
              self.input_box = QtWidgets.QLineEdit()
              self.input_box.setPlaceholderText("Type a message...")
              self.input_box.setMinimumHeight(40)
              self.input_box.setStyleSheet("""
                  QLineEdit {
                      border-radius: 12px;
                      padding: 8px;
                      background-color: rgba(255,255,255,0.95);
                      font-size: 16px;
                  }
              """)
              self.send_button = QtWidgets.QPushButton("Send")
              self.send_button.setMinimumHeight(40)
              self.send_button.setStyleSheet("""
                  QPushButton {
                      background-color: #4CAF50;
                      color: white;
                      border-radius: 10px;
                      padding: 8px 16px;
                      font-weight: bold;
                      font-size: 16px;
                  }
                  QPushButton:hover { background-color: #45a049; }
              """)
              input_layout.addWidget(self.input_box, stretch=1)
              input_layout.addWidget(self.send_button, stretch=0)
              main_layout.addLayout(input_layout)

              # Connect GUI signals
              self.send_button.clicked.connect(self.send_message)
              self.input_box.returnPressed.connect(self.send_message)

              # Track last sent message timestamp widget (simple approach)
              # If you want per-message tracking, change to a list/map of widgets per message id.
              self._last_message_timestamp = None

              # show window
              self.qt_widget.show()

          def send_message(self):
              """Called from GUI thread when user presses Send or Enter."""
              text = self.input_box.text().strip()
              if not text:
                  return

              addr = self.addr_box.currentText().strip()
              full_msg = f"{addr}:{text}"

              # Publish as PMT symbol/string on 'out' port
              try:
                  self.message_port_pub(pmt.intern("out"), pmt.intern(full_msg))
              except Exception:
                  # fallback to generic intern
                  self.message_port_pub(pmt.intern("out"), pmt.intern(full_msg))

              # Build outgoing bubble (right side)
              container = QtWidgets.QWidget()
              vbox = QtWidgets.QVBoxLayout()
              vbox.setContentsMargins(0, 0, 0, 0)
              vbox.setSpacing(4)

              # Scrollable area for long messages
              scroll = QtWidgets.QScrollArea()
              scroll.setWidgetResizable(True)
              scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)
              scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              scroll.setFrameShape(QtWidgets.QFrame.NoFrame)
              scroll.setStyleSheet("background: transparent; border: none;")

              bubble = QtWidgets.QLabel(text)  # show only body (user-friendly)
              bubble.setWordWrap(False)
              bubble.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              bubble.setStyleSheet("""
                  QLabel {
                      background-color: qlineargradient(x1:0,y1:0,x2:1,y2:1, stop:0 #4CAF50, stop:1 #66BB6A);
                      color: white;
                      border-radius: 12px;
                      padding: 8px 12px;
                      font-size: 14px;
                  }
              """)
              # shadow
              effect = QtWidgets.QGraphicsDropShadowEffect()
              effect.setBlurRadius(6)
              effect.setXOffset(2)
              effect.setYOffset(2)
              effect.setColor(QtGui.QColor(0, 0, 0, 80))
              bubble.setGraphicsEffect(effect)

              scroll.setWidget(bubble)
              scroll.setMinimumWidth(160)
              scroll.setMaximumWidth(520)

              # Timestamp pill (initially 'Sending...')
              timestamp = QtWidgets.QLabel("Sending...")
              timestamp.setStyleSheet("""
                  QLabel {
                      background-color: #2196F3;
                      color: white;
                      font-size: 11px;
                      border-radius: 8px;
                      padding: 2px 6px;
                  }
              """)
              timestamp.setAlignment(QtCore.Qt.AlignRight)
              timestamp.setSizePolicy(QtWidgets.QSizePolicy.Fixed, QtWidgets.QSizePolicy.Fixed)

              vbox.addWidget(scroll, alignment=QtCore.Qt.AlignRight)
              vbox.addWidget(timestamp, alignment=QtCore.Qt.AlignRight)
              container.setLayout(vbox)
              container.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Fixed)

              # Add to chat layout (right aligned)
              self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignRight)

              # Force layout update and scroll to bottom
              bubble.adjustSize()
              scroll.adjustSize()
              container.adjustSize()
              self.chat_container.adjustSize()
              QtWidgets.QApplication.processEvents()
              QtCore.QTimer.singleShot(20, lambda: self.scroll_area.verticalScrollBar().setValue(
                  self.scroll_area.verticalScrollBar().maximum()
              ))

              # Clear input and store timestamp widget for feedback updates
              self.input_box.clear()
              self._last_message_timestamp = timestamp

          def _process_feedback(self, msg_pmt):
              """
              Handler for 'feedback' port. Expected feedback values:
                - "TRUE" => show delivery time
                - "FALSE" => show 'Failed'
              """
              try:
                  if pmt.is_symbol(msg_pmt) or pmt.is_string(msg_pmt):
                      fb = pmt.symbol_to_string(msg_pmt)
                  else:
                      py = pmt.to_python(msg_pmt)
                      fb = str(py)
              except Exception:
                  fb = "<unreadable feedback>"

              print(fb)
              # Update last timestamp widget if available (simple single-last approach)
              if self._last_message_timestamp:
                  if fb == "TRUE":
                      self._last_message_timestamp.setText(datetime.now().strftime("%H:%M:%S"))
                      self._last_message_timestamp.setStyleSheet("""
                          QLabel {
                              background-color: #2196F3;
                              color: white;
                              font-size: 11px;
                              border-radius: 8px;
                              padding: 2px 6px;
                          }
                      """)
                  elif fb == "FALSE":
                      self._last_message_timestamp.setText("Failed")
                      self._last_message_timestamp.setStyleSheet("""
                          QLabel {
                              background-color: #F44336;
                              color: white;
                              font-size: 11px;
                              border-radius: 8px;
                              padding: 2px 6px;
                          }
                      """)

          def _receive_message(self, msg_pmt):
              """
              Handler for 'in_msg' port. Extracts string and posts it to GUI thread
              via _poster.sig so _display_incoming runs in Qt thread.
              """
              try:
                  if pmt.is_symbol(msg_pmt) or pmt.is_string(msg_pmt):
                      s = pmt.symbol_to_string(msg_pmt)
                  else:
                      py = pmt.to_python(msg_pmt)
                      s = str(py)
              except Exception:
                  s = "<unreadable message>"

              # Post to GUI-thread handler
              try:
                  self._poster.sig.emit(s)
              except Exception:
                  # If signal emit fails for any reason, try direct call in case we're already in Qt thread
                  try:
                      self._display_incoming(s)
                  except Exception:
                      print("[messenger_gui] failed to deliver incoming message to GUI:", s)

          def _display_incoming(self, full_msg):
              """
              Build incoming bubble (left aligned). full_msg expected in "addr:body" format.
              """
              # try to split "addr:body"
              if ":" in full_msg:
                  addr, body = full_msg.split(":", 1)
                  display_text = f"{body}"
                  header_text = f"{addr}"
              else:
                  display_text = full_msg
                  header_text = ""

              container = QtWidgets.QWidget()
              vbox = QtWidgets.QVBoxLayout()
              vbox.setContentsMargins(0, 0, 0, 0)
              vbox.setSpacing(4)

              scroll = QtWidgets.QScrollArea()
              scroll.setWidgetResizable(True)
              scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)
              scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              scroll.setFrameShape(QtWidgets.QFrame.NoFrame)
              scroll.setStyleSheet("background: transparent; border: none;")

              bubble = QtWidgets.QLabel(display_text)
              bubble.setWordWrap(False)
              bubble.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)
              bubble.setStyleSheet("""
                  QLabel {
                      background-color: qlineargradient(x1:0,y1:0,x2:1,y2:1, stop:0 #E1F5FE, stop:1 #B3E5FC);
                      color: #0B2545;
                      border-radius: 12px;
                      padding: 8px 12px;
                      font-size: 14px;
                  }
              """)

              # small header with sender address (optional)
              if header_text:
                  header = QtWidgets.QLabel(header_text)
                  header.setStyleSheet("font-size: 11px; color: #1565C0;")
                  header.setAlignment(QtCore.Qt.AlignLeft)
                  vbox.addWidget(header, alignment=QtCore.Qt.AlignLeft)

              scroll.setWidget(bubble)
              scroll.setMinimumWidth(160)
              scroll.setMaximumWidth(520)

              vbox.addWidget(scroll, alignment=QtCore.Qt.AlignLeft)

              # incoming messages do not have delivery timestamp pill (feedback relates to outgoing)
              container.setLayout(vbox)
              container.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Fixed)

              self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignLeft)

              # Update layout and scroll to bottom
              bubble.adjustSize()
              scroll.adjustSize()
              container.adjustSize()
              self.chat_container.adjustSize()
              QtWidgets.QApplication.processEvents()
              QtCore.QTimer.singleShot(20, lambda: self.scroll_area.verticalScrollBar().setValue(
                  self.scroll_area.verticalScrollBar().maximum()
              ))
    bg_image: r"C:\Users\Oshan\Desktop\message.jpg"
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block for GNU Radio - Mesh Network Packet Communication
      Implements packetization, Go-Back-N ARQ, and p-persistent ALOHA medium access
      No external CRC module required - implements CRC-16 CCITT manually
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import queue
      import time
      import random
      import struct
      import collections


      class blk(gr.sync_block):
          """
          Mesh Network Packet Communication Block
          Handles packet transmission/reception with Go-Back-N ARQ + ALOHA
          """

          def __init__(
              self,
              node_id = 1,
              aloha_prob = 0.3,
              timeout = 1.0,
              max_retries = 3,
              window_size = 4,
              aloha_backoff_min = 0.1,
              aloha_backoff_max = 0.5,
          ):
              """
              Arguments:
                  node_id:           Unique identifier for this node (1-255)
                  aloha_prob:        Transmission probability (p) for p-persistent ALOHA (0.0-1.0)
                  timeout:           ARQ timeout in seconds (timer for base of window)
                  max_retries:       Maximum window retransmission attempts before giving up
                  window_size:       Go-Back-N window size (number of outstanding frames)
                  aloha_backoff_min: Minimum backoff before (re)transmission when ALOHA defers
                  aloha_backoff_max: Maximum backoff before (re)transmission when ALOHA defers
              """
              gr.sync_block.__init__(
                  self,
                  name='Mesh Packet Comm GBN',
                  in_sig=None,
                  out_sig=None
              )

              # Node configuration
              self.node_id = node_id
              self.aloha_prob = float(aloha_prob)
              self.timeout = float(timeout)
              self.max_retries = int(max_retries)
              self.window_size = int(window_size)
              self.aloha_backoff_min = float(aloha_backoff_min)
              self.aloha_backoff_max = float(aloha_backoff_max)

              # Packet parameters
              # Preamble: long, random-ish pattern for sync
              b = random.getrandbits(8)
              self.PREAMBLE = bytes([b] * 32)
              self.SYNC_WORD = bytes([0x2D, 0xD4])
              self.MAX_PAYLOAD = 255
              self.CRC_SIZE = 2

              # Packet types
              self.PKT_DATA = 0x01
              self.PKT_ACK = 0x02

              # CRC-16 CCITT lookup table
              self.crc_table = self.generate_crc_table()

              # Queues
              self.tx_queue = queue.Queue()   # app -> link layer (messages to send)
              self.rx_queue = queue.Queue()   # PHY -> link layer (raw received bytes)
              self.ack_queue = queue.Queue()  # RX thread -> TX thread (parsed ACKs)

              # TX state (Go-Back-N)
              self.seq_num_tx = 0  # next sequence number to use (mod 256)
              # window: OrderedDict[seq] = {
              #   'packet': bytes,
              #   'feedback_sent': bool
              # }
              self.tx_window = collections.OrderedDict()
              self.window_timer_start = None
              self.window_retries = 0

              # RX state (per-source expected sequence for GBN)
              # expected_seq_rx[src_id] = next expected seq from that source
              self.expected_seq_rx = {}

              # RX byte buffer for packet extraction
              self.rx_buffer = bytes()

              # Statistics
              self.stats = {
                  'packets_sent': 0,
                  'packets_received': 0,
                  'acks_sent': 0,
                  'acks_received': 0,
                  'retransmissions': 0,
                  'crc_errors': 0,
                  'window_timeouts': 0,
              }

              # Threading
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_handler)
              self.rx_thread = threading.Thread(target=self.rx_handler)
              self.tx_thread.daemon = True
              self.rx_thread.daemon = True

              # Message ports
              self.port_msg_in = pmt.intern('msg_in')
              self.port_pdu_in = pmt.intern('pdu_in')
              self.port_msg_out = pmt.intern('msg_out')
              self.port_pdu_out = pmt.intern('pdu_out')
              self.port_feedback = pmt.intern('feedback')

              self.message_port_register_in(self.port_msg_in)
              self.message_port_register_in(self.port_pdu_in)
              self.message_port_register_out(self.port_msg_out)
              self.message_port_register_out(self.port_pdu_out)
              self.message_port_register_out(self.port_feedback)

              # Set message handlers
              self.set_msg_handler(self.port_msg_in, self.handle_msg_in)
              self.set_msg_handler(self.port_pdu_in, self.handle_pdu_in)

              # Start threads
              self.tx_thread.start()
              self.rx_thread.start()

              print(f"[Node {self.node_id}] Initialized (GBN+ALOHA) - Ready for communication")

          # -------------------------------------------------------------------------
          # CRC helpers
          # -------------------------------------------------------------------------
          def generate_crc_table(self):
              """Generate CRC-16 CCITT lookup table"""
              poly = 0x1021
              table = []
              for i in range(256):
                  crc = i << 8
                  for _ in range(8):
                      if crc & 0x8000:
                          crc = ((crc << 1) ^ poly) & 0xFFFF
                      else:
                          crc = (crc << 1) & 0xFFFF
                  table.append(crc)
              return table

          def calculate_crc16(self, data):
              """Calculate CRC-16 CCITT for given data"""
              crc = 0xFFFF
              for byte in data:
                  tbl_idx = ((crc >> 8) ^ byte) & 0xFF
                  crc = ((crc << 8) ^ self.crc_table[tbl_idx]) & 0xFFFF
              return crc

          # -------------------------------------------------------------------------
          # Upper-layer message handling
          # -------------------------------------------------------------------------
          def handle_msg_in(self, msg):
              """Handle incoming messages from GUI/application"""
              try:
                  # Handle string messages directly: "dst_id:message"
                  if pmt.is_symbol(msg):
                      text = pmt.symbol_to_string(msg)
                      if ':' in text:
                          dst_str, payload_str = text.split(':', 1)
                          try:
                              dst_id = int(dst_str)
                              data = payload_str.encode()
                              self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                              print(f"[Node {self.node_id}] Queued message to {dst_id}: {payload_str}")
                          except ValueError:
                              print(f"[Node {self.node_id}] Invalid destination ID in text message")

                  # Handle dictionary messages (Python dict via pmt.to_python)
                  elif pmt.is_dict(msg):
                      meta = pmt.to_python(msg)
                      if 'dst' in meta and 'data' in meta:
                          dst_id = meta['dst']
                          data = meta['data'].encode() if isinstance(meta['data'], str) else meta['data']
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued dict message to {dst_id}")

                  # Handle PDU-style pair: (meta, vec)
                  elif pmt.is_pair(msg):
                      meta = pmt.to_python(pmt.car(msg))
                      data = pmt.to_python(pmt.cdr(msg))
                      if isinstance(meta, dict) and 'dst' in meta:
                          dst_id = meta['dst']
                          if isinstance(data, str):
                              data = data.encode()
                          elif isinstance(data, list):
                              data = bytes(data)
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued PDU message to {dst_id}")

              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling msg_in: {e}")

          def handle_pdu_in(self, pdu):
              """Handle incoming PDUs from demodulator/PHY"""
              try:
                  if not pmt.is_pair(pdu):
                      return

                  meta = pmt.car(pdu)
                  data = pmt.cdr(pdu)

                  if pmt.is_u8vector(data):
                      rx_bytes = bytes(pmt.u8vector_elements(data))
                      self.rx_queue.put(rx_bytes)
                  elif pmt.is_uniform_vector(data):
                      elements = pmt.to_python(data)
                      rx_bytes = bytes([int(x) & 0xFF for x in elements])
                      self.rx_queue.put(rx_bytes)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling pdu_in: {e}")

          # -------------------------------------------------------------------------
          # Packet creation & parsing
          # -------------------------------------------------------------------------
          def create_packet(self, dst_id, seq_num, pkt_type, payload=b''):
              """Create a packet with headers and CRC"""
              packet = bytearray()

              # Preamble + sync
              packet.extend(self.PREAMBLE)
              packet.extend(self.SYNC_WORD)

              # Header
              packet.append(self.node_id)        # Source ID
              packet.append(dst_id & 0xFF)       # Destination ID
              packet.append(seq_num & 0xFF)      # Sequence number
              packet.append(pkt_type & 0xFF)     # Packet type
              packet.append(len(payload) & 0xFF) # Payload length

              # Payload (truncated to MAX_PAYLOAD)
              if payload:
                  packet.extend(payload[:self.MAX_PAYLOAD])

              # CRC over header + payload (not including preamble+sync)
              crc_data = bytes(packet[len(self.PREAMBLE) + len(self.SYNC_WORD):])
              crc_val = self.calculate_crc16(crc_data)
              packet.extend(struct.pack('>H', crc_val))

              return bytes(packet)

          def parse_packet(self, data):
              """Parse received packet and validate CRC. Returns dict or None."""
              try:
                  # Find sync word
                  sync_idx = data.find(self.SYNC_WORD)
                  if sync_idx == -1:
                      return None

                  start_idx = sync_idx + len(self.SYNC_WORD)

                  # Minimum: src(1) + dst(1) + seq(1) + type(1) + len(1) + CRC(2)
                  if len(data) < start_idx + 5 + self.CRC_SIZE:
                      return None

                  src_id = data[start_idx]
                  dst_id = data[start_idx + 1]
                  seq_num = data[start_idx + 2]
                  pkt_type = data[start_idx + 3]
                  payload_len = data[start_idx + 4]

                  total_len = start_idx + 5 + payload_len + self.CRC_SIZE
                  if len(data) < total_len:
                      return None

                  payload = data[start_idx + 5:start_idx + 5 + payload_len]
                  rx_crc = struct.unpack('>H', data[total_len - self.CRC_SIZE:total_len])[0]

                  crc_data = data[start_idx:total_len - self.CRC_SIZE]
                  calc_crc = self.calculate_crc16(crc_data)

                  if rx_crc != calc_crc:
                      self.stats['crc_errors'] += 1
                      print(f"[Node {self.node_id}] CRC mismatch (expected: {calc_crc:04X}, got: {rx_crc:04X})")
                      return None

                  return {
                      'src': src_id,
                      'dst': dst_id,
                      'seq': seq_num,
                      'type': pkt_type,
                      'payload': payload,
                      'consumed': total_len
                  }

              except Exception as e:
                  print(f"[Node {self.node_id}] Error parsing packet: {e}")
                  return None

          # -------------------------------------------------------------------------
          # Medium access (ALOHA) + physical transmit
          # -------------------------------------------------------------------------
          def send_with_aloha(self, packet):
              """
              Apply simple p-persistent ALOHA:
              - With probability p = aloha_prob, transmit immediately.
              - With probability (1-p), wait a random backoff then transmit.
              """
              try:
                  if random.random() > self.aloha_prob:
                      backoff = random.uniform(self.aloha_backoff_min, self.aloha_backoff_max)
                      print(f"[Node {self.node_id}] ALOHA backoff {backoff:.2f}s")
                      time.sleep(backoff)

                  self.transmit_packet(packet)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error in send_with_aloha: {e}")

          def transmit_packet(self, packet):
              """Send packet to physical layer as a PDU"""
              try:
                  vec = pmt.init_u8vector(len(packet), list(packet))
                  pdu = pmt.cons(pmt.PMT_NIL, vec)
                  self.message_port_pub(self.port_pdu_out, pdu)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error transmitting packet: {e}")

          # -------------------------------------------------------------------------
          # Go-Back-N TX thread
          # -------------------------------------------------------------------------
          def process_acks(self):
              """Process all pending ACKs and slide the GBN window."""
              try:
                  while True:
                      ack = self.ack_queue.get_nowait()
                      ack_seq = ack['seq']
                      # In this simple implementation we don't distinguish by src.
                      if not self.tx_window:
                          continue

                      if ack_seq not in self.tx_window:
                          # Could be a cumulative ACK for multiple packets.
                          # We remove from the left until we pass ack_seq if it appears.
                          keys = list(self.tx_window.keys())
                          if ack_seq in keys:
                              idx = keys.index(ack_seq)
                              to_remove = keys[:idx + 1]
                          else:
                              # If ack_seq not present, we assume it's older than current base (duplicate) and ignore.
                              continue
                      else:
                          # ack_seq is present; treat as cumulative ACK up to this seq.
                          keys = list(self.tx_window.keys())
                          idx = keys.index(ack_seq)
                          to_remove = keys[:idx + 1]

                      # Remove all ACKed packets from window (cumulative ACK)
                      for s in to_remove:
                          entry = self.tx_window.pop(s, None)
                          if entry is not None and not entry.get('feedback_sent', False):
                              self.send_feedback(True)
                              entry['feedback_sent'] = True

                      self.stats['acks_received'] += 1

                      # Reset timer/retries based on new window state
                      if self.tx_window:
                          self.window_timer_start = time.time()
                          self.window_retries = 0
                      else:
                          self.window_timer_start = None
                          self.window_retries = 0

              except queue.Empty:
                  # No more ACKs for now
                  pass
              except Exception as e:
                  print(f"[Node {self.node_id}] Error processing ACKs: {e}")

          def fill_window_from_queue(self):
              """Pull new messages from tx_queue into the Go-Back-N window if there's space."""
              try:
                  while len(self.tx_window) < self.window_size:
                      try:
                          msg = self.tx_queue.get_nowait()
                      except queue.Empty:
                          break

                      dst = msg['dst']
                      data = msg.get('data', b'')
                      pkt_type = msg.get('type', self.PKT_DATA)

                      # Assign sequence number
                      seq = self.seq_num_tx
                      self.seq_num_tx = (self.seq_num_tx + 1) % 256

                      packet = self.create_packet(dst, seq, pkt_type, data)

                      # For broadcast we typically don't do ARQ; transmit once and don't put in window
                      if dst == 0xFF or pkt_type != self.PKT_DATA:
                          print(f"[Node {self.node_id}] TX (no ARQ): seq={seq} dst={dst}")
                          self.send_with_aloha(packet)
                          self.stats['packets_sent'] += 1
                          continue

                      # Reliable (GBN-managed) packet
                      self.tx_window[seq] = {
                          'packet': packet,
                          'feedback_sent': False,
                      }

                      print(f"[Node {self.node_id}] TX: Sending DATA seq={seq} dst={dst} (window size={len(self.tx_window)})")
                      self.send_with_aloha(packet)
                      self.stats['packets_sent'] += 1

                      # If this is the first packet in window, start timer
                      if len(self.tx_window) == 1:
                          self.window_timer_start = time.time()
                          self.window_retries = 0

              except Exception as e:
                  print(f"[Node {self.node_id}] Error filling window: {e}")

          def check_window_timeout(self):
              """Check for Go-Back-N timeout on the base of the window and retransmit if needed."""
              if not self.tx_window:
                  return

              if self.window_timer_start is None:
                  return

              now = time.time()
              if now - self.window_timer_start < self.timeout:
                  return

              # Timeout occurred for base of window
              self.stats['window_timeouts'] += 1
              self.window_retries += 1
              base_seq = next(iter(self.tx_window.keys()))
              print(f"[Node {self.node_id}] GBN timeout at seq={base_seq}, retry {self.window_retries}/{self.max_retries}")

              if self.window_retries > self.max_retries:
                  print(f"[Node {self.node_id}] GBN: Max retries exceeded, dropping window")
                  # Mark all outstanding packets as failed
                  for _seq, entry in list(self.tx_window.items()):
                      if not entry.get('feedback_sent', False):
                          self.send_feedback(False)
                          entry['feedback_sent'] = True
                  self.tx_window.clear()
                  self.window_timer_start = None
                  self.window_retries = 0
                  return

              # Go-Back-N: retransmit all packets currently in the window
              for seq, entry in self.tx_window.items():
                  print(f"[Node {self.node_id}] GBN retransmit seq={seq}")
                  self.send_with_aloha(entry['packet'])
                  self.stats['retransmissions'] += 1

              # Restart timer for the base
              self.window_timer_start = time.time()

          def tx_handler(self):
              """Thread for handling Go-Back-N transmission + ALOHA medium access."""
              while self.running:
                  try:
                      # 1) Process all ACKs
                      self.process_acks()

                      # 2) Check for timeout on window base
                      self.check_window_timeout()

                      # 3) Fill window with new packets from tx_queue if space
                      self.fill_window_from_queue()

                      # Small sleep to avoid busy-wait
                      time.sleep(0.01)

                  except Exception as e:
                      print(f"[Node {self.node_id}] TX handler error: {e}")

          # -------------------------------------------------------------------------
          # RX thread (packetization + GBN receiver side)
          # -------------------------------------------------------------------------
          def rx_handler(self):
              """Thread for handling packet reception and GBN RX logic."""
              while self.running:
                  try:
                      try:
                          rx_data = self.rx_queue.get(timeout=0.1)
                      except queue.Empty:
                          continue

                      # Append to RX buffer
                      self.rx_buffer += rx_data

                      # Extract packets from buffer
                      while len(self.rx_buffer) > 0:
                          pkt = self.parse_packet(self.rx_buffer)

                          if pkt is None:
                              # No valid packet at current alignment; drop one byte and re-try
                              if len(self.rx_buffer) > 1:
                                  self.rx_buffer = self.rx_buffer[1:]
                              else:
                                  self.rx_buffer = bytes()
                              continue

                          # Remove processed bytes
                          self.rx_buffer = self.rx_buffer[pkt['consumed']:]

                          # Addressing: packet must be for us or broadcast
                          if pkt['dst'] != self.node_id and pkt['dst'] != 0xFF:
                              print(f"[Node {self.node_id}] RX: Packet not for us (dst={pkt['dst']})")
                              continue

                          if pkt['type'] == self.PKT_DATA:
                              self.handle_data_packet(pkt)
                          elif pkt['type'] == self.PKT_ACK:
                              self.handle_ack_packet(pkt)

                  except Exception as e:
                      print(f"[Node {self.node_id}] RX handler error: {e}")

          def handle_data_packet(self, pkt):
              """Handle incoming DATA packet with GBN receiver logic."""
              src = pkt['src']
              seq = pkt['seq']
              payload = pkt['payload']

              self.stats['packets_received'] += 1
              expected = self.expected_seq_rx.get(src, 0)

              if seq == expected:
                  # In-order packet: accept and advance
                  print(f"[Node {self.node_id}] RX: In-order DATA from {src}, seq={seq} (expected={expected})")
                  self.expected_seq_rx[src] = (expected + 1) % 256
                  ack_seq = seq
                  is_new = True
              else:
                  # Out-of-order or duplicate
                  print(f"[Node {self.node_id}] RX: Out-of-order/dup DATA from {src}, seq={seq}, expected={expected}")
                  # Last correctly received in-order seq is expected-1 (mod 256)
                  if expected == 0:
                      ack_seq = 255
                  else:
                      ack_seq = (expected - 1) & 0xFF
                  is_new = False

              # Send ACK for last in-order seq (GBN cumulative ACK)
              ack_packet = self.create_packet(src, ack_seq, self.PKT_ACK)
              print(f"[Node {self.node_id}] RX: Sending ACK seq={ack_seq} to {src}")
              self.send_with_aloha(ack_packet)
              self.stats['acks_sent'] += 1

              # Deliver only new, in-order packets to the application
              if is_new:
                  self.forward_to_app(src, payload)

          def handle_ack_packet(self, pkt):
              """Handle incoming ACK packet (push to ack_queue for TX thread)."""
              src = pkt['src']
              seq = pkt['seq']
              print(f"[Node {self.node_id}] RX: ACK from node {src}, seq={seq}")
              # Push seq to ack queue; TX thread handles window sliding
              self.ack_queue.put({'src': src, 'seq': seq})

          # -------------------------------------------------------------------------
          # Upper-layer delivery & feedback
          # -------------------------------------------------------------------------
          def forward_to_app(self, src_id, data):
              """Forward received data to application/GUI."""
              try:
                  message = data.decode('utf-8', errors='ignore')
                  output = f"[From Node {src_id}]: {message}"

                  # Simple string out
                  msg = pmt.intern(output)
                  self.message_port_pub(self.port_msg_out, msg)

                  # (Optional) could also send a dict PDU here if needed
                  print(f"[Node {self.node_id}] Message delivered: {output}")

              except Exception as e:
                  print(f"[Node {self.node_id}] Error forwarding to app: {e}")

          def send_feedback(self, success):
              """Send boolean-like feedback (TRUE/FALSE) to feedback port."""
              try:
                  text = "TRUE" if success else "FALSE"
                  msg = pmt.intern(text)
                  self.message_port_pub(self.port_feedback, msg)
              except Exception as e:
                  print(f"[Node {self.node_id}] Error sending feedback: {e}")

          # -------------------------------------------------------------------------
          # GNU Radio boilerplate
          # -------------------------------------------------------------------------
          def work(self, input_items, output_items):
              """Main work function (not used for message-passing block)."""
              return 0

          def stop(self):
              """Clean shutdown"""
              print(f"\n[Node {self.node_id}] Statistics:")
              print(f"  Packets sent:      {self.stats['packets_sent']}")
              print(f"  Packets received:  {self.stats['packets_received']}")
              print(f"  ACKs sent:         {self.stats['acks_sent']}")
              print(f"  ACKs received:     {self.stats['acks_received']}")
              print(f"  Retransmissions:   {self.stats['retransmissions']}")
              print(f"  CRC errors:        {self.stats['crc_errors']}")
              print(f"  Window timeouts:   {self.stats['window_timeouts']}")

              self.running = False
              if self.tx_thread.is_alive():
                  self.tx_thread.join()
              if self.rx_thread.is_alive():
                  self.rx_thread.join()
              return True
    aloha_backoff_max: '0.5'
    aloha_backoff_min: '0.1'
    aloha_prob: '0.3'
    max_retries: '3'
    node_id: '1'
    timeout: '1.0'
    window_size: '4'
  states: {state: disabled}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block for GNU Radio - Mesh Network Packet Communication
      Implements packetization, Go-Back-N ARQ, and p-persistent ALOHA medium access
      No external CRC module required - implements CRC-16 CCITT manually
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import queue
      import time
      import random
      import struct
      import collections


      class blk(gr.sync_block):
          """
          Mesh Network Packet Communication Block
          Handles packet transmission/reception with Go-Back-N ARQ + ALOHA
          """

          def __init__(
              self,
              node_id = 1,
              aloha_prob = 0.3,
              timeout = 1.0,
              max_retries = 3,
              window_size = 4,
              aloha_backoff_min = 0.1,
              aloha_backoff_max = 0.5,
          ):
              """
              Arguments:
                  node_id:           Unique identifier for this node (1-255)
                  aloha_prob:        Transmission probability (p) for p-persistent ALOHA (0.0-1.0)
                  timeout:           ARQ timeout in seconds (timer for base of window)
                  max_retries:       Maximum window retransmission attempts before giving up
                  window_size:       Go-Back-N window size (number of outstanding frames)
                  aloha_backoff_min: Minimum backoff before (re)transmission when ALOHA defers
                  aloha_backoff_max: Maximum backoff before (re)transmission when ALOHA defers
              """
              gr.sync_block.__init__(
                  self,
                  name='Mesh Packet Comm GBN',
                  in_sig=None,
                  out_sig=None
              )

              # Node configuration
              self.node_id = node_id
              self.aloha_prob = float(aloha_prob)
              self.timeout = float(timeout)
              self.max_retries = int(max_retries)
              self.window_size = int(window_size)
              self.aloha_backoff_min = float(aloha_backoff_min)
              self.aloha_backoff_max = float(aloha_backoff_max)

              # Packet parameters
              # Preamble: long, random-ish pattern for sync
              b = random.getrandbits(8)
              self.PREAMBLE = bytes([b] * 32)
              self.SYNC_WORD = bytes([0x2D, 0xD4])
              self.MAX_PAYLOAD = 255
              self.CRC_SIZE = 2

              # Packet types
              self.PKT_DATA = 0x01
              self.PKT_ACK = 0x02

              # CRC-16 CCITT lookup table
              self.crc_table = self.generate_crc_table()

              # Queues
              self.tx_queue = queue.Queue()   # app -> link layer (messages to send)
              self.rx_queue = queue.Queue()   # PHY -> link layer (raw received bytes)
              self.ack_queue = queue.Queue()  # RX thread -> TX thread (parsed ACKs)

              # TX state (Go-Back-N)
              self.seq_num_tx = 0  # next sequence number to use (mod 256)
              # window: OrderedDict[seq] = {
              #   'packet': bytes,
              #   'feedback_sent': bool
              # }
              self.tx_window = collections.OrderedDict()
              self.window_timer_start = None
              self.window_retries = 0

              # RX state (per-source expected sequence for GBN)
              # expected_seq_rx[src_id] = next expected seq from that source
              self.expected_seq_rx = {}

              # RX byte buffer for packet extraction
              self.rx_buffer = bytes()

              # Statistics
              self.stats = {
                  'packets_sent': 0,
                  'packets_received': 0,
                  'acks_sent': 0,
                  'acks_received': 0,
                  'retransmissions': 0,
                  'crc_errors': 0,
                  'window_timeouts': 0,
              }

              # Threading
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_handler)
              self.rx_thread = threading.Thread(target=self.rx_handler)
              self.tx_thread.daemon = True
              self.rx_thread.daemon = True

              # Message ports
              self.port_msg_in = pmt.intern('msg_in')
              self.port_pdu_in = pmt.intern('pdu_in')
              self.port_msg_out = pmt.intern('msg_out')
              self.port_pdu_out = pmt.intern('pdu_out')
              self.port_feedback = pmt.intern('feedback')

              self.message_port_register_in(self.port_msg_in)
              self.message_port_register_in(self.port_pdu_in)
              self.message_port_register_out(self.port_msg_out)
              self.message_port_register_out(self.port_pdu_out)
              self.message_port_register_out(self.port_feedback)

              # Set message handlers
              self.set_msg_handler(self.port_msg_in, self.handle_msg_in)
              self.set_msg_handler(self.port_pdu_in, self.handle_pdu_in)

              # Start threads
              self.tx_thread.start()
              self.rx_thread.start()

              print(f"[Node {self.node_id}] Initialized (GBN+ALOHA) - Ready for communication")

          # -------------------------------------------------------------------------
          # CRC helpers
          # -------------------------------------------------------------------------
          def generate_crc_table(self):
              """Generate CRC-16 CCITT lookup table"""
              poly = 0x1021
              table = []
              for i in range(256):
                  crc = i << 8
                  for _ in range(8):
                      if crc & 0x8000:
                          crc = ((crc << 1) ^ poly) & 0xFFFF
                      else:
                          crc = (crc << 1) & 0xFFFF
                  table.append(crc)
              return table

          def calculate_crc16(self, data):
              """Calculate CRC-16 CCITT for given data"""
              crc = 0xFFFF
              for byte in data:
                  tbl_idx = ((crc >> 8) ^ byte) & 0xFF
                  crc = ((crc << 8) ^ self.crc_table[tbl_idx]) & 0xFFFF
              return crc

          # -------------------------------------------------------------------------
          # Upper-layer message handling
          # -------------------------------------------------------------------------
          def handle_msg_in(self, msg):
              """Handle incoming messages from GUI/application"""
              try:
                  # Handle string messages directly: "dst_id:message"
                  if pmt.is_symbol(msg):
                      text = pmt.symbol_to_string(msg)
                      if ':' in text:
                          dst_str, payload_str = text.split(':', 1)
                          try:
                              dst_id = int(dst_str)
                              data = payload_str.encode()
                              self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                              print(f"[Node {self.node_id}] Queued message to {dst_id}: {payload_str}")
                          except ValueError:
                              print(f"[Node {self.node_id}] Invalid destination ID in text message")

                  # Handle dictionary messages (Python dict via pmt.to_python)
                  elif pmt.is_dict(msg):
                      meta = pmt.to_python(msg)
                      if 'dst' in meta and 'data' in meta:
                          dst_id = meta['dst']
                          data = meta['data'].encode() if isinstance(meta['data'], str) else meta['data']
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued dict message to {dst_id}")

                  # Handle PDU-style pair: (meta, vec)
                  elif pmt.is_pair(msg):
                      meta = pmt.to_python(pmt.car(msg))
                      data = pmt.to_python(pmt.cdr(msg))
                      if isinstance(meta, dict) and 'dst' in meta:
                          dst_id = meta['dst']
                          if isinstance(data, str):
                              data = data.encode()
                          elif isinstance(data, list):
                              data = bytes(data)
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued PDU message to {dst_id}")

              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling msg_in: {e}")

          def handle_pdu_in(self, pdu):
              """Handle incoming PDUs from demodulator/PHY"""
              try:
                  if not pmt.is_pair(pdu):
                      return

                  meta = pmt.car(pdu)
                  data = pmt.cdr(pdu)

                  if pmt.is_u8vector(data):
                      rx_bytes = bytes(pmt.u8vector_elements(data))
                      self.rx_queue.put(rx_bytes)
                  elif pmt.is_uniform_vector(data):
                      elements = pmt.to_python(data)
                      rx_bytes = bytes([int(x) & 0xFF for x in elements])
                      self.rx_queue.put(rx_bytes)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling pdu_in: {e}")

          # -------------------------------------------------------------------------
          # Packet creation & parsing
          # -------------------------------------------------------------------------
          def create_packet(self, dst_id, seq_num, pkt_type, payload=b''):
              """Create a packet with headers and CRC"""
              packet = bytearray()

              # Preamble + sync
              packet.extend(self.PREAMBLE)
              packet.extend(self.SYNC_WORD)

              # Header
              packet.append(self.node_id)        # Source ID
              packet.append(dst_id & 0xFF)       # Destination ID
              packet.append(seq_num & 0xFF)      # Sequence number
              packet.append(pkt_type & 0xFF)     # Packet type
              packet.append(len(payload) & 0xFF) # Payload length

              # Payload (truncated to MAX_PAYLOAD)
              if payload:
                  packet.extend(payload[:self.MAX_PAYLOAD])

              # CRC over header + payload (not including preamble+sync)
              crc_data = bytes(packet[len(self.PREAMBLE) + len(self.SYNC_WORD):])
              crc_val = self.calculate_crc16(crc_data)
              packet.extend(struct.pack('>H', crc_val))

              return bytes(packet)

          def parse_packet(self, data):
              """Parse received packet and validate CRC. Returns dict or None."""
              try:
                  # Find sync word
                  sync_idx = data.find(self.SYNC_WORD)
                  if sync_idx == -1:
                      return None

                  start_idx = sync_idx + len(self.SYNC_WORD)

                  # Minimum: src(1) + dst(1) + seq(1) + type(1) + len(1) + CRC(2)
                  if len(data) < start_idx + 5 + self.CRC_SIZE:
                      return None

                  src_id = data[start_idx]
                  dst_id = data[start_idx + 1]
                  seq_num = data[start_idx + 2]
                  pkt_type = data[start_idx + 3]
                  payload_len = data[start_idx + 4]

                  total_len = start_idx + 5 + payload_len + self.CRC_SIZE
                  if len(data) < total_len:
                      return None

                  payload = data[start_idx + 5:start_idx + 5 + payload_len]
                  rx_crc = struct.unpack('>H', data[total_len - self.CRC_SIZE:total_len])[0]

                  crc_data = data[start_idx:total_len - self.CRC_SIZE]
                  calc_crc = self.calculate_crc16(crc_data)

                  if rx_crc != calc_crc:
                      self.stats['crc_errors'] += 1
                      print(f"[Node {self.node_id}] CRC mismatch (expected: {calc_crc:04X}, got: {rx_crc:04X})")
                      return None

                  return {
                      'src': src_id,
                      'dst': dst_id,
                      'seq': seq_num,
                      'type': pkt_type,
                      'payload': payload,
                      'consumed': total_len
                  }

              except Exception as e:
                  print(f"[Node {self.node_id}] Error parsing packet: {e}")
                  return None

          # -------------------------------------------------------------------------
          # Medium access (ALOHA) + physical transmit
          # -------------------------------------------------------------------------
          def send_with_aloha(self, packet):
              """
              Apply simple p-persistent ALOHA:
              - With probability p = aloha_prob, transmit immediately.
              - With probability (1-p), wait a random backoff then transmit.
              """
              try:
                  if random.random() > self.aloha_prob:
                      backoff = random.uniform(self.aloha_backoff_min, self.aloha_backoff_max)
                      print(f"[Node {self.node_id}] ALOHA backoff {backoff:.2f}s")
                      time.sleep(backoff)

                  self.transmit_packet(packet)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error in send_with_aloha: {e}")

          def transmit_packet(self, packet):
              """Send packet to physical layer as a PDU"""
              try:
                  vec = pmt.init_u8vector(len(packet), list(packet))
                  pdu = pmt.cons(pmt.PMT_NIL, vec)
                  self.message_port_pub(self.port_pdu_out, pdu)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error transmitting packet: {e}")

          # -------------------------------------------------------------------------
          # Go-Back-N TX thread
          # -------------------------------------------------------------------------
          def process_acks(self):
              """Process all pending ACKs and slide the GBN window."""
              try:
                  while True:
                      ack = self.ack_queue.get_nowait()
                      ack_seq = ack['seq']
                      # In this simple implementation we don't distinguish by src.
                      if not self.tx_window:
                          continue

                      if ack_seq not in self.tx_window:
                          # Could be a cumulative ACK for multiple packets.
                          # We remove from the left until we pass ack_seq if it appears.
                          keys = list(self.tx_window.keys())
                          if ack_seq in keys:
                              idx = keys.index(ack_seq)
                              to_remove = keys[:idx + 1]
                          else:
                              # If ack_seq not present, we assume it's older than current base (duplicate) and ignore.
                              continue
                      else:
                          # ack_seq is present; treat as cumulative ACK up to this seq.
                          keys = list(self.tx_window.keys())
                          idx = keys.index(ack_seq)
                          to_remove = keys[:idx + 1]

                      # Remove all ACKed packets from window (cumulative ACK)
                      for s in to_remove:
                          entry = self.tx_window.pop(s, None)
                          if entry is not None and not entry.get('feedback_sent', False):
                              self.send_feedback(True)
                              entry['feedback_sent'] = True

                      self.stats['acks_received'] += 1

                      # Reset timer/retries based on new window state
                      if self.tx_window:
                          self.window_timer_start = time.time()
                          self.window_retries = 0
                      else:
                          self.window_timer_start = None
                          self.window_retries = 0

              except queue.Empty:
                  # No more ACKs for now
                  pass
              except Exception as e:
                  print(f"[Node {self.node_id}] Error processing ACKs: {e}")

          def fill_window_from_queue(self):
              """Pull new messages from tx_queue into the Go-Back-N window if there's space."""
              try:
                  while len(self.tx_window) < self.window_size:
                      try:
                          msg = self.tx_queue.get_nowait()
                      except queue.Empty:
                          break

                      dst = msg['dst']
                      data = msg.get('data', b'')
                      pkt_type = msg.get('type', self.PKT_DATA)

                      # Assign sequence number
                      seq = self.seq_num_tx
                      self.seq_num_tx = (self.seq_num_tx + 1) % 256

                      packet = self.create_packet(dst, seq, pkt_type, data)

                      # For broadcast we typically don't do ARQ; transmit once and don't put in window
                      if dst == 0xFF or pkt_type != self.PKT_DATA:
                          print(f"[Node {self.node_id}] TX (no ARQ): seq={seq} dst={dst}")
                          self.send_with_aloha(packet)
                          self.stats['packets_sent'] += 1
                          continue

                      # Reliable (GBN-managed) packet
                      self.tx_window[seq] = {
                          'packet': packet,
                          'feedback_sent': False,
                      }

                      print(f"[Node {self.node_id}] TX: Sending DATA seq={seq} dst={dst} (window size={len(self.tx_window)})")
                      self.send_with_aloha(packet)
                      self.stats['packets_sent'] += 1

                      # If this is the first packet in window, start timer
                      if len(self.tx_window) == 1:
                          self.window_timer_start = time.time()
                          self.window_retries = 0

              except Exception as e:
                  print(f"[Node {self.node_id}] Error filling window: {e}")

          def check_window_timeout(self):
              """Check for Go-Back-N timeout on the base of the window and retransmit if needed."""
              if not self.tx_window:
                  return

              if self.window_timer_start is None:
                  return

              now = time.time()
              if now - self.window_timer_start < self.timeout:
                  return

              # Timeout occurred for base of window
              self.stats['window_timeouts'] += 1
              self.window_retries += 1
              base_seq = next(iter(self.tx_window.keys()))
              print(f"[Node {self.node_id}] GBN timeout at seq={base_seq}, retry {self.window_retries}/{self.max_retries}")

              if self.window_retries > self.max_retries:
                  print(f"[Node {self.node_id}] GBN: Max retries exceeded, dropping window")
                  # Mark all outstanding packets as failed
                  for _seq, entry in list(self.tx_window.items()):
                      if not entry.get('feedback_sent', False):
                          self.send_feedback(False)
                          entry['feedback_sent'] = True
                  self.tx_window.clear()
                  self.window_timer_start = None
                  self.window_retries = 0
                  return

              # Go-Back-N: retransmit all packets currently in the window
              for seq, entry in self.tx_window.items():
                  print(f"[Node {self.node_id}] GBN retransmit seq={seq}")
                  self.send_with_aloha(entry['packet'])
                  self.stats['retransmissions'] += 1

              # Restart timer for the base
              self.window_timer_start = time.time()

          def tx_handler(self):
              """Thread for handling Go-Back-N transmission + ALOHA medium access."""
              while self.running:
                  try:
                      # 1) Process all ACKs
                      self.process_acks()

                      # 2) Check for timeout on window base
                      self.check_window_timeout()

                      # 3) Fill window with new packets from tx_queue if space
                      self.fill_window_from_queue()

                      # Small sleep to avoid busy-wait
                      time.sleep(0.01)

                  except Exception as e:
                      print(f"[Node {self.node_id}] TX handler error: {e}")

          # -------------------------------------------------------------------------
          # RX thread (packetization + GBN receiver side)
          # -------------------------------------------------------------------------
          def rx_handler(self):
              """Thread for handling packet reception and GBN RX logic."""
              while self.running:
                  try:
                      try:
                          rx_data = self.rx_queue.get(timeout=0.1)
                      except queue.Empty:
                          continue

                      # Append to RX buffer
                      self.rx_buffer += rx_data

                      # Extract packets from buffer
                      while len(self.rx_buffer) > 0:
                          pkt = self.parse_packet(self.rx_buffer)

                          if pkt is None:
                              # No valid packet at current alignment; drop one byte and re-try
                              if len(self.rx_buffer) > 1:
                                  self.rx_buffer = self.rx_buffer[1:]
                              else:
                                  self.rx_buffer = bytes()
                              continue

                          # Remove processed bytes
                          self.rx_buffer = self.rx_buffer[pkt['consumed']:]

                          # Addressing: packet must be for us or broadcast
                          if pkt['dst'] != self.node_id and pkt['dst'] != 0xFF:
                              print(f"[Node {self.node_id}] RX: Packet not for us (dst={pkt['dst']})")
                              continue

                          if pkt['type'] == self.PKT_DATA:
                              self.handle_data_packet(pkt)
                          elif pkt['type'] == self.PKT_ACK:
                              self.handle_ack_packet(pkt)

                  except Exception as e:
                      print(f"[Node {self.node_id}] RX handler error: {e}")

          def handle_data_packet(self, pkt):
              """Handle incoming DATA packet with GBN receiver logic."""
              src = pkt['src']
              seq = pkt['seq']
              payload = pkt['payload']

              self.stats['packets_received'] += 1
              expected = self.expected_seq_rx.get(src, 0)

              if seq == expected:
                  # In-order packet: accept and advance
                  print(f"[Node {self.node_id}] RX: In-order DATA from {src}, seq={seq} (expected={expected})")
                  self.expected_seq_rx[src] = (expected + 1) % 256
                  ack_seq = seq
                  is_new = True
              else:
                  # Out-of-order or duplicate
                  print(f"[Node {self.node_id}] RX: Out-of-order/dup DATA from {src}, seq={seq}, expected={expected}")
                  # Last correctly received in-order seq is expected-1 (mod 256)
                  if expected == 0:
                      ack_seq = 255
                  else:
                      ack_seq = (expected - 1) & 0xFF
                  is_new = False

              # Send ACK for last in-order seq (GBN cumulative ACK)
              ack_packet = self.create_packet(src, ack_seq, self.PKT_ACK)
              print(f"[Node {self.node_id}] RX: Sending ACK seq={ack_seq} to {src}")
              self.send_with_aloha(ack_packet)
              self.stats['acks_sent'] += 1

              # Deliver only new, in-order packets to the application
              if is_new:
                  self.forward_to_app(src, payload)

          def handle_ack_packet(self, pkt):
              """Handle incoming ACK packet (push to ack_queue for TX thread)."""
              src = pkt['src']
              seq = pkt['seq']
              print(f"[Node {self.node_id}] RX: ACK from node {src}, seq={seq}")
              # Push seq to ack queue; TX thread handles window sliding
              self.ack_queue.put({'src': src, 'seq': seq})

          # -------------------------------------------------------------------------
          # Upper-layer delivery & feedback
          # -------------------------------------------------------------------------
          def forward_to_app(self, src_id, data):
              """Forward received data to application/GUI."""
              try:
                  message = data.decode('utf-8', errors='ignore')
                  output = f"[From Node {src_id}]: {message}"

                  # Simple string out
                  msg = pmt.intern(output)
                  self.message_port_pub(self.port_msg_out, msg)

                  # (Optional) could also send a dict PDU here if needed
                  print(f"[Node {self.node_id}] Message delivered: {output}")

              except Exception as e:
                  print(f"[Node {self.node_id}] Error forwarding to app: {e}")

          def send_feedback(self, success):
              """Send boolean-like feedback (TRUE/FALSE) to feedback port."""
              try:
                  text = "TRUE" if success else "FALSE"
                  msg = pmt.intern(text)
                  self.message_port_pub(self.port_feedback, msg)
              except Exception as e:
                  print(f"[Node {self.node_id}] Error sending feedback: {e}")

          # -------------------------------------------------------------------------
          # GNU Radio boilerplate
          # -------------------------------------------------------------------------
          def work(self, input_items, output_items):
              """Main work function (not used for message-passing block)."""
              return 0

          def stop(self):
              """Clean shutdown"""
              print(f"\n[Node {self.node_id}] Statistics:")
              print(f"  Packets sent:      {self.stats['packets_sent']}")
              print(f"  Packets received:  {self.stats['packets_received']}")
              print(f"  ACKs sent:         {self.stats['acks_sent']}")
              print(f"  ACKs received:     {self.stats['acks_received']}")
              print(f"  Retransmissions:   {self.stats['retransmissions']}")
              print(f"  CRC errors:        {self.stats['crc_errors']}")
              print(f"  Window timeouts:   {self.stats['window_timeouts']}")

              self.running = False
              if self.tx_thread.is_alive():
                  self.tx_thread.join()
              if self.rx_thread.is_alive():
                  self.rx_thread.join()
              return True
    aloha_backoff_max: '0.5'
    aloha_backoff_min: '0.1'
    aloha_prob: '0.3'
    max_retries: '3'
    node_id: '2'
    timeout: '1.0'
    window_size: '4'
  states: {state: disabled}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block for GNU Radio - Mesh Network Packet Communication
      Implements packetization, Go-Back-N ARQ, and p-persistent ALOHA medium access
      No external CRC module required - implements CRC-16 CCITT manually

      Now also sends a raw random-byte sync burst before each new GBN window.
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import queue
      import time
      import random
      import struct
      import collections


      class blk(gr.sync_block):
          """
          Mesh Network Packet Communication Block
          Handles packet transmission/reception with Go-Back-N ARQ + ALOHA
          """

          def __init__(
              self,
              node_id = 1,
              aloha_prob = 0.3,
              timeout = 1.0,
              max_retries = 3,
              window_size = 4,
              aloha_backoff_min = 0.1,
              aloha_backoff_max = 0.5,
              sync_burst_len = 1000,
          ):
              """
              Arguments:
                  node_id:           Unique identifier for this node (1-255)
                  aloha_prob:        Transmission probability (p) for p-persistent ALOHA (0.0-1.0)
                  timeout:           ARQ timeout in seconds (timer for base of window)
                  max_retries:       Maximum window retransmission attempts before giving up
                  window_size:       Go-Back-N window size (number of outstanding frames)
                  aloha_backoff_min: Minimum backoff before (re)transmission when ALOHA defers
                  aloha_backoff_max: Maximum backoff before (re)transmission when ALOHA defers
                  sync_burst_len:    Length (in bytes) of the raw random sync burst sent
                                     immediately before the first DATA packet of each new window
              """
              gr.sync_block.__init__(
                  self,
                  name='Mesh Packet Comm GBN with sync',
                  in_sig=None,
                  out_sig=None
              )

              # Node configuration
              self.node_id = node_id
              self.aloha_prob = float(aloha_prob)
              self.timeout = float(timeout)
              self.max_retries = int(max_retries)
              self.window_size = int(window_size)
              self.aloha_backoff_min = float(aloha_backoff_min)
              self.aloha_backoff_max = float(aloha_backoff_max)

              # Sync burst configuration (raw random bytes, no headers)
              self.sync_burst_len = int(sync_burst_len)

              # Packet parameters
              # Preamble: long, random-ish pattern for sync (currently fixed 0xAA)
              self.PREAMBLE = bytes([0xAA, 0xAA, 0xAA, 0xAA])
              self.SYNC_WORD = bytes([0x2D, 0xD4])
              self.MAX_PAYLOAD = 255
              self.CRC_SIZE = 2

              # Packet types
              self.PKT_DATA = 0x01
              self.PKT_ACK = 0x02

              # CRC-16 CCITT lookup table
              self.crc_table = self.generate_crc_table()

              # Queues
              self.tx_queue = queue.Queue()   # app -> link layer (messages to send)
              self.rx_queue = queue.Queue()   # PHY -> link layer (raw received bytes)
              self.ack_queue = queue.Queue()  # RX thread -> TX thread (parsed ACKs)

              # TX state (Go-Back-N)
              self.seq_num_tx = 0  # next sequence number to use (mod 256)
              # window: OrderedDict[seq] = {
              #   'packet': bytes,
              #   'feedback_sent': bool
              # }
              self.tx_window = collections.OrderedDict()
              self.window_timer_start = None
              self.window_retries = 0

              # RX state (per-source expected sequence for GBN)
              # expected_seq_rx[src_id] = next expected seq from that source
              self.expected_seq_rx = {}

              # RX byte buffer for packet extraction
              self.rx_buffer = bytes()

              # Statistics
              self.stats = {
                  'packets_sent': 0,
                  'packets_received': 0,
                  'acks_sent': 0,
                  'acks_received': 0,
                  'retransmissions': 0,
                  'crc_errors': 0,
                  'window_timeouts': 0,
              }

              # Threading
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_handler)
              self.rx_thread = threading.Thread(target=self.rx_handler)
              self.tx_thread.daemon = True
              self.rx_thread.daemon = True

              # Message ports
              self.port_msg_in = pmt.intern('msg_in')
              self.port_pdu_in = pmt.intern('pdu_in')
              self.port_msg_out = pmt.intern('msg_out')
              self.port_pdu_out = pmt.intern('pdu_out')
              self.port_feedback = pmt.intern('feedback')

              self.message_port_register_in(self.port_msg_in)
              self.message_port_register_in(self.port_pdu_in)
              self.message_port_register_out(self.port_msg_out)
              self.message_port_register_out(self.port_pdu_out)
              self.message_port_register_out(self.port_feedback)

              # Set message handlers
              self.set_msg_handler(self.port_msg_in, self.handle_msg_in)
              self.set_msg_handler(self.port_pdu_in, self.handle_pdu_in)

              # Start threads
              self.tx_thread.start()
              self.rx_thread.start()

              print(f"[Node {self.node_id}] Initialized (GBN+ALOHA) - Ready for communication")

          # -------------------------------------------------------------------------
          # CRC helpers
          # -------------------------------------------------------------------------
          def generate_crc_table(self):
              """Generate CRC-16 CCITT lookup table"""
              poly = 0x1021
              table = []
              for i in range(256):
                  crc = i << 8
                  for _ in range(8):
                      if crc & 0x8000:
                          crc = ((crc << 1) ^ poly) & 0xFFFF
                      else:
                          crc = (crc << 1) & 0xFFFF
                  table.append(crc)
              return table

          def calculate_crc16(self, data):
              """Calculate CRC-16 CCITT for given data"""
              crc = 0xFFFF
              for byte in data:
                  tbl_idx = ((crc >> 8) ^ byte) & 0xFF
                  crc = ((crc << 8) ^ self.crc_table[tbl_idx]) & 0xFFFF
              return crc

          # -------------------------------------------------------------------------
          # Upper-layer message handling
          # -------------------------------------------------------------------------
          def handle_msg_in(self, msg):
              """Handle incoming messages from GUI/application"""
              try:
                  # Handle string messages directly: "dst_id:message"
                  if pmt.is_symbol(msg):
                      text = pmt.symbol_to_string(msg)
                      if ':' in text:
                          dst_str, payload_str = text.split(':', 1)
                          try:
                              dst_id = int(dst_str)
                              data = payload_str.encode()
                              self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                              print(f"[Node {self.node_id}] Queued message to {dst_id}: {payload_str}")
                          except ValueError:
                              print(f"[Node {self.node_id}] Invalid destination ID in text message")

                  # Handle dictionary messages (Python dict via pmt.to_python)
                  elif pmt.is_dict(msg):
                      meta = pmt.to_python(msg)
                      if 'dst' in meta and 'data' in meta:
                          dst_id = meta['dst']
                          data = meta['data'].encode() if isinstance(meta['data'], str) else meta['data']
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued dict message to {dst_id}")

                  # Handle PDU-style pair: (meta, vec)
                  elif pmt.is_pair(msg):
                      meta = pmt.to_python(pmt.car(msg))
                      data = pmt.to_python(pmt.cdr(msg))
                      if isinstance(meta, dict) and 'dst' in meta:
                          dst_id = meta['dst']
                          if isinstance(data, str):
                              data = data.encode()
                          elif isinstance(data, list):
                              data = bytes(data)
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued PDU message to {dst_id}")

              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling msg_in: {e}")

          def handle_pdu_in(self, pdu):
              """Handle incoming PDUs from demodulator/PHY"""
              try:
                  if not pmt.is_pair(pdu):
                      return

                  meta = pmt.car(pdu)
                  data = pmt.cdr(pdu)

                  if pmt.is_u8vector(data):
                      rx_bytes = bytes(pmt.u8vector_elements(data))
                      self.rx_queue.put(rx_bytes)
                  elif pmt.is_uniform_vector(data):
                      elements = pmt.to_python(data)
                      rx_bytes = bytes([int(x) & 0xFF for x in elements])
                      self.rx_queue.put(rx_bytes)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling pdu_in: {e}")

          # -------------------------------------------------------------------------
          # Packet creation & parsing
          # -------------------------------------------------------------------------
          def create_packet(self, dst_id, seq_num, pkt_type, payload=b''):
              """Create a packet with headers and CRC"""
              packet = bytearray()

              # Preamble + sync
              packet.extend(self.PREAMBLE)
              packet.extend(self.SYNC_WORD)

              # Header
              packet.append(self.node_id)        # Source ID
              packet.append(dst_id & 0xFF)       # Destination ID
              packet.append(seq_num & 0xFF)      # Sequence number
              packet.append(pkt_type & 0xFF)     # Packet type
              packet.append(len(payload) & 0xFF) # Payload length

              # Payload (truncated to MAX_PAYLOAD)
              if payload:
                  packet.extend(payload[:self.MAX_PAYLOAD])

              # CRC over header + payload (not including preamble+sync)
              crc_data = bytes(packet[len(self.PREAMBLE) + len(self.SYNC_WORD):])
              crc_val = self.calculate_crc16(crc_data)
              packet.extend(struct.pack('>H', crc_val))

              return bytes(packet)

          def parse_packet(self, data):
              """Parse received packet and validate CRC. Returns dict or None."""
              try:
                  # Find sync word
                  sync_idx = data.find(self.SYNC_WORD)
                  if sync_idx == -1:
                      return None

                  start_idx = sync_idx + len(self.SYNC_WORD)

                  # Minimum: src(1) + dst(1) + seq(1) + type(1) + len(1) + CRC(2)
                  if len(data) < start_idx + 5 + self.CRC_SIZE:
                      return None

                  src_id = data[start_idx]
                  dst_id = data[start_idx + 1]
                  seq_num = data[start_idx + 2]
                  pkt_type = data[start_idx + 3]
                  payload_len = data[start_idx + 4]

                  total_len = start_idx + 5 + payload_len + self.CRC_SIZE
                  if len(data) < total_len:
                      return None

                  payload = data[start_idx + 5:start_idx + 5 + payload_len]
                  rx_crc = struct.unpack('>H', data[total_len - self.CRC_SIZE:total_len])[0]

                  crc_data = data[start_idx:total_len - self.CRC_SIZE]
                  calc_crc = self.calculate_crc16(crc_data)

                  if rx_crc != calc_crc:
                      self.stats['crc_errors'] += 1
                      print(f"[Node {self.node_id}] CRC mismatch (expected: {calc_crc:04X}, got: {rx_crc:04X})")
                      return None

                  return {
                      'src': src_id,
                      'dst': dst_id,
                      'seq': seq_num,
                      'type': pkt_type,
                      'payload': payload,
                      'consumed': total_len
                  }

              except Exception as e:
                  print(f"[Node {self.node_id}] Error parsing packet: {e}")
                  return None

          # -------------------------------------------------------------------------
          # Medium access (ALOHA) + physical transmit
          # -------------------------------------------------------------------------
          def send_with_aloha(self, packet):
              """
              Apply simple p-persistent ALOHA:
              - With probability p = aloha_prob, transmit immediately.
              - With probability (1-p), wait a random backoff then transmit.
              'packet' can be a full framed packet or raw bytes (e.g., sync burst).
              """
              try:
                  if random.random() > self.aloha_prob:
                      backoff = random.uniform(self.aloha_backoff_min, self.aloha_backoff_max)
                      print(f"[Node {self.node_id}] ALOHA backoff {backoff:.2f}s")
                      time.sleep(backoff)

                  self.transmit_packet(packet)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error in send_with_aloha: {e}")

          def transmit_packet(self, packet):
              """Send packet (raw bytes) to physical layer as a PDU"""
              try:
                  vec = pmt.init_u8vector(len(packet), list(packet))
                  pdu = pmt.cons(pmt.PMT_NIL, vec)
                  self.message_port_pub(self.port_pdu_out, pdu)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error transmitting packet: {e}")

          # -------------------------------------------------------------------------
          # Sync burst (window preamble, no headers)
          # -------------------------------------------------------------------------
          def send_sync_burst(self):
              """
              Send a large random-byte burst (no headers) before a new GBN window.
              This is intended to help the receiver's synchronizer/AGC/etc.
              """
              try:
                  if self.sync_burst_len <= 0:
                      return
                  burst = bytes(random.getrandbits(8) for _ in range(self.sync_burst_len))
                  print(f"[Node {self.node_id}] TX: Sending sync burst ({len(burst)} bytes)")
                  self.send_with_aloha(burst)
              except Exception as e:
                  print(f"[Node {self.node_id}] Error sending sync burst: {e}")

          # -------------------------------------------------------------------------
          # Go-Back-N TX thread
          # -------------------------------------------------------------------------
          def process_acks(self):
              """Process all pending ACKs and slide the GBN window."""
              try:
                  while True:
                      ack = self.ack_queue.get_nowait()
                      ack_seq = ack['seq']
                      # In this simple implementation we don't distinguish by src.
                      if not self.tx_window:
                          continue

                      if ack_seq not in self.tx_window:
                          # Could be a cumulative ACK for multiple packets.
                          # We remove from the left until we pass ack_seq if it appears.
                          keys = list(self.tx_window.keys())
                          if ack_seq in keys:
                              idx = keys.index(ack_seq)
                              to_remove = keys[:idx + 1]
                          else:
                              # If ack_seq not present, we assume it's older than current base (duplicate) and ignore.
                              continue
                      else:
                          # ack_seq is present; treat as cumulative ACK up to this seq.
                          keys = list(self.tx_window.keys())
                          idx = keys.index(ack_seq)
                          to_remove = keys[:idx + 1]

                      # Remove all ACKed packets from window (cumulative ACK)
                      for s in to_remove:
                          entry = self.tx_window.pop(s, None)
                          if entry is not None and not entry.get('feedback_sent', False):
                              self.send_feedback(True)
                              entry['feedback_sent'] = True

                      self.stats['acks_received'] += 1

                      # Reset timer/retries based on new window state
                      if self.tx_window:
                          self.window_timer_start = time.time()
                          self.window_retries = 0
                      else:
                          self.window_timer_start = None
                          self.window_retries = 0

              except queue.Empty:
                  # No more ACKs for now
                  pass
              except Exception as e:
                  print(f"[Node {self.node_id}] Error processing ACKs: {e}")

          def fill_window_from_queue(self):
              """Pull new messages from tx_queue into the Go-Back-N window if there's space."""
              try:
                  while len(self.tx_window) < self.window_size:
                      try:
                          msg = self.tx_queue.get_nowait()
                      except queue.Empty:
                          break

                      dst = msg['dst']
                      data = msg.get('data', b'')
                      pkt_type = msg.get('type', self.PKT_DATA)

                      # Assign sequence number
                      seq = self.seq_num_tx
                      self.seq_num_tx = (self.seq_num_tx + 1) % 256

                      packet = self.create_packet(dst, seq, pkt_type, data)

                      # For broadcast we typically don't do ARQ; transmit once and don't put in window
                      if dst == 0xFF or pkt_type != self.PKT_DATA:
                          print(f"[Node {self.node_id}] TX (no ARQ): seq={seq} dst={dst}")
                          self.send_with_aloha(packet)
                          self.stats['packets_sent'] += 1
                          continue

                      # Reliable (GBN-managed) packet
                      is_new_window = (len(self.tx_window) == 0)

                      self.tx_window[seq] = {
                          'packet': packet,
                          'feedback_sent': False,
                      }

                      # If this is the first packet of a new window, send a sync burst first
                      if is_new_window:
                          self.send_sync_burst()

                      print(f"[Node {self.node_id}] TX: Sending DATA seq={seq} dst={dst} (window size={len(self.tx_window)})")
                      self.send_with_aloha(packet)
                      self.stats['packets_sent'] += 1

                      # If this is the first packet in window, start timer
                      if len(self.tx_window) == 1:
                          self.window_timer_start = time.time()
                          self.window_retries = 0

              except Exception as e:
                  print(f"[Node {self.node_id}] Error filling window: {e}")

          def check_window_timeout(self):
              """Check for Go-Back-N timeout on the base of the window and retransmit if needed."""
              if not self.tx_window:
                  return

              if self.window_timer_start is None:
                  return

              now = time.time()
              if now - self.window_timer_start < self.timeout:
                  return

              # Timeout occurred for base of window
              self.stats['window_timeouts'] += 1
              self.window_retries += 1
              base_seq = next(iter(self.tx_window.keys()))
              print(f"[Node {self.node_id}] GBN timeout at seq={base_seq}, retry {self.window_retries}/{self.max_retries}")

              if self.window_retries > self.max_retries:
                  print(f"[Node {self.node_id}] GBN: Max retries exceeded, dropping window")
                  # Mark all outstanding packets as failed
                  for _seq, entry in list(self.tx_window.items()):
                      if not entry.get('feedback_sent', False):
                          self.send_feedback(False)
                          entry['feedback_sent'] = True
                  self.tx_window.clear()
                  self.window_timer_start = None
                  self.window_retries = 0
                  return

              # Go-Back-N: retransmit all packets currently in the window
              for seq, entry in self.tx_window.items():
                  print(f"[Node {self.node_id}] GBN retransmit seq={seq}")
                  self.send_with_aloha(entry['packet'])
                  self.stats['retransmissions'] += 1

              # Restart timer for the base
              self.window_timer_start = time.time()

          def tx_handler(self):
              """Thread for handling Go-Back-N transmission + ALOHA medium access."""
              while self.running:
                  try:
                      # 1) Process all ACKs
                      self.process_acks()

                      # 2) Check for timeout on window base
                      self.check_window_timeout()

                      # 3) Fill window with new packets from tx_queue if space
                      self.fill_window_from_queue()

                      # Small sleep to avoid busy-wait
                      time.sleep(0.01)

                  except Exception as e:
                      print(f"[Node {self.node_id}] TX handler error: {e}")

          # -------------------------------------------------------------------------
          # RX thread (packetization + GBN receiver side)
          # -------------------------------------------------------------------------
          def rx_handler(self):
              """Thread for handling packet reception and GBN RX logic."""
              while self.running:
                  try:
                      try:
                          rx_data = self.rx_queue.get(timeout=0.1)
                      except queue.Empty:
                          continue

                      # Append to RX buffer
                      self.rx_buffer += rx_data

                      # Extract packets from buffer
                      while len(self.rx_buffer) > 0:
                          pkt = self.parse_packet(self.rx_buffer)

                          if pkt is None:
                              # No valid packet at current alignment; drop one byte and re-try
                              if len(self.rx_buffer) > 1:
                                  self.rx_buffer = self.rx_buffer[1:]
                              else:
                                  self.rx_buffer = bytes()
                              continue

                          # Remove processed bytes
                          self.rx_buffer = self.rx_buffer[pkt['consumed']:]

                          # Addressing: packet must be for us or broadcast
                          if pkt['dst'] != self.node_id and pkt['dst'] != 0xFF:
                              print(f"[Node {self.node_id}] RX: Packet not for us (dst={pkt['dst']})")
                              continue

                          if pkt['type'] == self.PKT_DATA:
                              self.handle_data_packet(pkt)
                          elif pkt['type'] == self.PKT_ACK:
                              self.handle_ack_packet(pkt)

                  except Exception as e:
                      print(f"[Node {self.node_id}] RX handler error: {e}")

          def handle_data_packet(self, pkt):
              """Handle incoming DATA packet with GBN receiver logic."""
              src = pkt['src']
              seq = pkt['seq']
              payload = pkt['payload']

              self.stats['packets_received'] += 1
              expected = self.expected_seq_rx.get(src, 0)

              if seq == expected:
                  # In-order packet: accept and advance
                  print(f"[Node {self.node_id}] RX: In-order DATA from {src}, seq={seq} (expected={expected})")
                  self.expected_seq_rx[src] = (expected + 1) % 256
                  ack_seq = seq
                  is_new = True
              else:
                  # Out-of-order or duplicate
                  print(f"[Node {self.node_id}] RX: Out-of-order/dup DATA from {src}, seq={seq}, expected={expected}")
                  # Last correctly received in-order seq is expected-1 (mod 256)
                  if expected == 0:
                      ack_seq = 255
                  else:
                      ack_seq = (expected - 1) & 0xFF
                  is_new = False

              # Send ACK for last in-order seq (GBN cumulative ACK)
              ack_packet = self.create_packet(src, ack_seq, self.PKT_ACK)
              print(f"[Node {self.node_id}] RX: Sending ACK seq={ack_seq} to {src}")
              self.send_with_aloha(ack_packet)
              self.stats['acks_sent'] += 1

              # Deliver only new, in-order packets to the application
              if is_new:
                  self.forward_to_app(src, payload)

          def handle_ack_packet(self, pkt):
              """Handle incoming ACK packet (push to ack_queue for TX thread)."""
              src = pkt['src']
              seq = pkt['seq']
              print(f"[Node {self.node_id}] RX: ACK from node {src}, seq={seq}")
              # Push seq to ack queue; TX thread handles window sliding
              self.ack_queue.put({'src': src, 'seq': seq})

          # -------------------------------------------------------------------------
          # Upper-layer delivery & feedback
          # -------------------------------------------------------------------------
          def forward_to_app(self, src_id, data):
              """Forward received data to application/GUI."""
              try:
                  message = data.decode('utf-8', errors='ignore')
                  output = f"[From Node {src_id}]: {message}"

                  # Simple string out
                  msg = pmt.intern(output)
                  self.message_port_pub(self.port_msg_out, msg)

                  # (Optional) could also send a dict PDU here if needed
                  print(f"[Node {self.node_id}] Message delivered: {output}")

              except Exception as e:
                  print(f"[Node {self.node_id}] Error forwarding to app: {e}")

          def send_feedback(self, success):
              """Send boolean-like feedback (TRUE/FALSE) to feedback port."""
              try:
                  text = "TRUE" if success else "FALSE"
                  msg = pmt.intern(text)
                  self.message_port_pub(self.port_feedback, msg)
              except Exception as e:
                  print(f"[Node {self.node_id}] Error sending feedback: {e}")

          # -------------------------------------------------------------------------
          # GNU Radio boilerplate
          # -------------------------------------------------------------------------
          def work(self, input_items, output_items):
              """Main work function (not used for message-passing block)."""
              return 0

          def stop(self):
              """Clean shutdown"""
              print(f"\n[Node {self.node_id}] Statistics:")
              print(f"  Packets sent:      {self.stats['packets_sent']}")
              print(f"  Packets received:  {self.stats['packets_received']}")
              print(f"  ACKs sent:         {self.stats['acks_sent']}")
              print(f"  ACKs received:     {self.stats['acks_received']}")
              print(f"  Retransmissions:   {self.stats['retransmissions']}")
              print(f"  CRC errors:        {self.stats['crc_errors']}")
              print(f"  Window timeouts:   {self.stats['window_timeouts']}")

              self.running = False
              if self.tx_thread.is_alive():
                  self.tx_thread.join()
              if self.rx_thread.is_alive():
                  self.rx_thread.join()
              return True
    aloha_backoff_max: '0.5'
    aloha_backoff_min: '0.1'
    aloha_prob: '0.3'
    max_retries: '3'
    node_id: '1'
    sync_burst_len: '1000'
    timeout: '1.0'
    window_size: '4'
  states: {}
- name: epy_block_1_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block for GNU Radio - Mesh Network Packet Communication
      Implements packetization, Go-Back-N ARQ, and p-persistent ALOHA medium access
      No external CRC module required - implements CRC-16 CCITT manually

      Now also sends a raw random-byte sync burst before each new GBN window.
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import queue
      import time
      import random
      import struct
      import collections


      class blk(gr.sync_block):
          """
          Mesh Network Packet Communication Block
          Handles packet transmission/reception with Go-Back-N ARQ + ALOHA
          """

          def __init__(
              self,
              node_id = 1,
              aloha_prob = 0.3,
              timeout = 1.0,
              max_retries = 3,
              window_size = 4,
              aloha_backoff_min = 0.1,
              aloha_backoff_max = 0.5,
              sync_burst_len = 1000,
          ):
              """
              Arguments:
                  node_id:           Unique identifier for this node (1-255)
                  aloha_prob:        Transmission probability (p) for p-persistent ALOHA (0.0-1.0)
                  timeout:           ARQ timeout in seconds (timer for base of window)
                  max_retries:       Maximum window retransmission attempts before giving up
                  window_size:       Go-Back-N window size (number of outstanding frames)
                  aloha_backoff_min: Minimum backoff before (re)transmission when ALOHA defers
                  aloha_backoff_max: Maximum backoff before (re)transmission when ALOHA defers
                  sync_burst_len:    Length (in bytes) of the raw random sync burst sent
                                     immediately before the first DATA packet of each new window
              """
              gr.sync_block.__init__(
                  self,
                  name='Mesh Packet Comm GBN with sync',
                  in_sig=None,
                  out_sig=None
              )

              # Node configuration
              self.node_id = node_id
              self.aloha_prob = float(aloha_prob)
              self.timeout = float(timeout)
              self.max_retries = int(max_retries)
              self.window_size = int(window_size)
              self.aloha_backoff_min = float(aloha_backoff_min)
              self.aloha_backoff_max = float(aloha_backoff_max)

              # Sync burst configuration (raw random bytes, no headers)
              self.sync_burst_len = int(sync_burst_len)

              # Packet parameters
              # Preamble: long, random-ish pattern for sync (currently fixed 0xAA)
              self.PREAMBLE = bytes([0xAA, 0xAA, 0xAA, 0xAA])
              self.SYNC_WORD = bytes([0x2D, 0xD4])
              self.MAX_PAYLOAD = 255
              self.CRC_SIZE = 2

              # Packet types
              self.PKT_DATA = 0x01
              self.PKT_ACK = 0x02

              # CRC-16 CCITT lookup table
              self.crc_table = self.generate_crc_table()

              # Queues
              self.tx_queue = queue.Queue()   # app -> link layer (messages to send)
              self.rx_queue = queue.Queue()   # PHY -> link layer (raw received bytes)
              self.ack_queue = queue.Queue()  # RX thread -> TX thread (parsed ACKs)

              # TX state (Go-Back-N)
              self.seq_num_tx = 0  # next sequence number to use (mod 256)
              # window: OrderedDict[seq] = {
              #   'packet': bytes,
              #   'feedback_sent': bool
              # }
              self.tx_window = collections.OrderedDict()
              self.window_timer_start = None
              self.window_retries = 0

              # RX state (per-source expected sequence for GBN)
              # expected_seq_rx[src_id] = next expected seq from that source
              self.expected_seq_rx = {}

              # RX byte buffer for packet extraction
              self.rx_buffer = bytes()

              # Statistics
              self.stats = {
                  'packets_sent': 0,
                  'packets_received': 0,
                  'acks_sent': 0,
                  'acks_received': 0,
                  'retransmissions': 0,
                  'crc_errors': 0,
                  'window_timeouts': 0,
              }

              # Threading
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_handler)
              self.rx_thread = threading.Thread(target=self.rx_handler)
              self.tx_thread.daemon = True
              self.rx_thread.daemon = True

              # Message ports
              self.port_msg_in = pmt.intern('msg_in')
              self.port_pdu_in = pmt.intern('pdu_in')
              self.port_msg_out = pmt.intern('msg_out')
              self.port_pdu_out = pmt.intern('pdu_out')
              self.port_feedback = pmt.intern('feedback')

              self.message_port_register_in(self.port_msg_in)
              self.message_port_register_in(self.port_pdu_in)
              self.message_port_register_out(self.port_msg_out)
              self.message_port_register_out(self.port_pdu_out)
              self.message_port_register_out(self.port_feedback)

              # Set message handlers
              self.set_msg_handler(self.port_msg_in, self.handle_msg_in)
              self.set_msg_handler(self.port_pdu_in, self.handle_pdu_in)

              # Start threads
              self.tx_thread.start()
              self.rx_thread.start()

              print(f"[Node {self.node_id}] Initialized (GBN+ALOHA) - Ready for communication")

          # -------------------------------------------------------------------------
          # CRC helpers
          # -------------------------------------------------------------------------
          def generate_crc_table(self):
              """Generate CRC-16 CCITT lookup table"""
              poly = 0x1021
              table = []
              for i in range(256):
                  crc = i << 8
                  for _ in range(8):
                      if crc & 0x8000:
                          crc = ((crc << 1) ^ poly) & 0xFFFF
                      else:
                          crc = (crc << 1) & 0xFFFF
                  table.append(crc)
              return table

          def calculate_crc16(self, data):
              """Calculate CRC-16 CCITT for given data"""
              crc = 0xFFFF
              for byte in data:
                  tbl_idx = ((crc >> 8) ^ byte) & 0xFF
                  crc = ((crc << 8) ^ self.crc_table[tbl_idx]) & 0xFFFF
              return crc

          # -------------------------------------------------------------------------
          # Upper-layer message handling
          # -------------------------------------------------------------------------
          def handle_msg_in(self, msg):
              """Handle incoming messages from GUI/application"""
              try:
                  # Handle string messages directly: "dst_id:message"
                  if pmt.is_symbol(msg):
                      text = pmt.symbol_to_string(msg)
                      if ':' in text:
                          dst_str, payload_str = text.split(':', 1)
                          try:
                              dst_id = int(dst_str)
                              data = payload_str.encode()
                              self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                              print(f"[Node {self.node_id}] Queued message to {dst_id}: {payload_str}")
                          except ValueError:
                              print(f"[Node {self.node_id}] Invalid destination ID in text message")

                  # Handle dictionary messages (Python dict via pmt.to_python)
                  elif pmt.is_dict(msg):
                      meta = pmt.to_python(msg)
                      if 'dst' in meta and 'data' in meta:
                          dst_id = meta['dst']
                          data = meta['data'].encode() if isinstance(meta['data'], str) else meta['data']
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued dict message to {dst_id}")

                  # Handle PDU-style pair: (meta, vec)
                  elif pmt.is_pair(msg):
                      meta = pmt.to_python(pmt.car(msg))
                      data = pmt.to_python(pmt.cdr(msg))
                      if isinstance(meta, dict) and 'dst' in meta:
                          dst_id = meta['dst']
                          if isinstance(data, str):
                              data = data.encode()
                          elif isinstance(data, list):
                              data = bytes(data)
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued PDU message to {dst_id}")

              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling msg_in: {e}")

          def handle_pdu_in(self, pdu):
              """Handle incoming PDUs from demodulator/PHY"""
              try:
                  if not pmt.is_pair(pdu):
                      return

                  meta = pmt.car(pdu)
                  data = pmt.cdr(pdu)

                  if pmt.is_u8vector(data):
                      rx_bytes = bytes(pmt.u8vector_elements(data))
                      self.rx_queue.put(rx_bytes)
                  elif pmt.is_uniform_vector(data):
                      elements = pmt.to_python(data)
                      rx_bytes = bytes([int(x) & 0xFF for x in elements])
                      self.rx_queue.put(rx_bytes)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling pdu_in: {e}")

          # -------------------------------------------------------------------------
          # Packet creation & parsing
          # -------------------------------------------------------------------------
          def create_packet(self, dst_id, seq_num, pkt_type, payload=b''):
              """Create a packet with headers and CRC"""
              packet = bytearray()

              # Preamble + sync
              packet.extend(self.PREAMBLE)
              packet.extend(self.SYNC_WORD)

              # Header
              packet.append(self.node_id)        # Source ID
              packet.append(dst_id & 0xFF)       # Destination ID
              packet.append(seq_num & 0xFF)      # Sequence number
              packet.append(pkt_type & 0xFF)     # Packet type
              packet.append(len(payload) & 0xFF) # Payload length

              # Payload (truncated to MAX_PAYLOAD)
              if payload:
                  packet.extend(payload[:self.MAX_PAYLOAD])

              # CRC over header + payload (not including preamble+sync)
              crc_data = bytes(packet[len(self.PREAMBLE) + len(self.SYNC_WORD):])
              crc_val = self.calculate_crc16(crc_data)
              packet.extend(struct.pack('>H', crc_val))

              return bytes(packet)

          def parse_packet(self, data):
              """Parse received packet and validate CRC. Returns dict or None."""
              try:
                  # Find sync word
                  sync_idx = data.find(self.SYNC_WORD)
                  if sync_idx == -1:
                      return None

                  start_idx = sync_idx + len(self.SYNC_WORD)

                  # Minimum: src(1) + dst(1) + seq(1) + type(1) + len(1) + CRC(2)
                  if len(data) < start_idx + 5 + self.CRC_SIZE:
                      return None

                  src_id = data[start_idx]
                  dst_id = data[start_idx + 1]
                  seq_num = data[start_idx + 2]
                  pkt_type = data[start_idx + 3]
                  payload_len = data[start_idx + 4]

                  total_len = start_idx + 5 + payload_len + self.CRC_SIZE
                  if len(data) < total_len:
                      return None

                  payload = data[start_idx + 5:start_idx + 5 + payload_len]
                  rx_crc = struct.unpack('>H', data[total_len - self.CRC_SIZE:total_len])[0]

                  crc_data = data[start_idx:total_len - self.CRC_SIZE]
                  calc_crc = self.calculate_crc16(crc_data)

                  if rx_crc != calc_crc:
                      self.stats['crc_errors'] += 1
                      print(f"[Node {self.node_id}] CRC mismatch (expected: {calc_crc:04X}, got: {rx_crc:04X})")
                      return None

                  return {
                      'src': src_id,
                      'dst': dst_id,
                      'seq': seq_num,
                      'type': pkt_type,
                      'payload': payload,
                      'consumed': total_len
                  }

              except Exception as e:
                  print(f"[Node {self.node_id}] Error parsing packet: {e}")
                  return None

          # -------------------------------------------------------------------------
          # Medium access (ALOHA) + physical transmit
          # -------------------------------------------------------------------------
          def send_with_aloha(self, packet):
              """
              Apply simple p-persistent ALOHA:
              - With probability p = aloha_prob, transmit immediately.
              - With probability (1-p), wait a random backoff then transmit.
              'packet' can be a full framed packet or raw bytes (e.g., sync burst).
              """
              try:
                  if random.random() > self.aloha_prob:
                      backoff = random.uniform(self.aloha_backoff_min, self.aloha_backoff_max)
                      print(f"[Node {self.node_id}] ALOHA backoff {backoff:.2f}s")
                      time.sleep(backoff)

                  self.transmit_packet(packet)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error in send_with_aloha: {e}")

          def transmit_packet(self, packet):
              """Send packet (raw bytes) to physical layer as a PDU"""
              try:
                  vec = pmt.init_u8vector(len(packet), list(packet))
                  pdu = pmt.cons(pmt.PMT_NIL, vec)
                  self.message_port_pub(self.port_pdu_out, pdu)

              except Exception as e:
                  print(f"[Node {self.node_id}] Error transmitting packet: {e}")

          # -------------------------------------------------------------------------
          # Sync burst (window preamble, no headers)
          # -------------------------------------------------------------------------
          def send_sync_burst(self):
              """
              Send a large random-byte burst (no headers) before a new GBN window.
              This is intended to help the receiver's synchronizer/AGC/etc.
              """
              try:
                  if self.sync_burst_len <= 0:
                      return
                  burst = bytes(random.getrandbits(8) for _ in range(self.sync_burst_len))
                  print(f"[Node {self.node_id}] TX: Sending sync burst ({len(burst)} bytes)")
                  self.send_with_aloha(burst)
              except Exception as e:
                  print(f"[Node {self.node_id}] Error sending sync burst: {e}")

          # -------------------------------------------------------------------------
          # Go-Back-N TX thread
          # -------------------------------------------------------------------------
          def process_acks(self):
              """Process all pending ACKs and slide the GBN window."""
              try:
                  while True:
                      ack = self.ack_queue.get_nowait()
                      ack_seq = ack['seq']
                      # In this simple implementation we don't distinguish by src.
                      if not self.tx_window:
                          continue

                      if ack_seq not in self.tx_window:
                          # Could be a cumulative ACK for multiple packets.
                          # We remove from the left until we pass ack_seq if it appears.
                          keys = list(self.tx_window.keys())
                          if ack_seq in keys:
                              idx = keys.index(ack_seq)
                              to_remove = keys[:idx + 1]
                          else:
                              # If ack_seq not present, we assume it's older than current base (duplicate) and ignore.
                              continue
                      else:
                          # ack_seq is present; treat as cumulative ACK up to this seq.
                          keys = list(self.tx_window.keys())
                          idx = keys.index(ack_seq)
                          to_remove = keys[:idx + 1]

                      # Remove all ACKed packets from window (cumulative ACK)
                      for s in to_remove:
                          entry = self.tx_window.pop(s, None)
                          if entry is not None and not entry.get('feedback_sent', False):
                              self.send_feedback(True)
                              entry['feedback_sent'] = True

                      self.stats['acks_received'] += 1

                      # Reset timer/retries based on new window state
                      if self.tx_window:
                          self.window_timer_start = time.time()
                          self.window_retries = 0
                      else:
                          self.window_timer_start = None
                          self.window_retries = 0

              except queue.Empty:
                  # No more ACKs for now
                  pass
              except Exception as e:
                  print(f"[Node {self.node_id}] Error processing ACKs: {e}")

          def fill_window_from_queue(self):
              """Pull new messages from tx_queue into the Go-Back-N window if there's space."""
              try:
                  while len(self.tx_window) < self.window_size:
                      try:
                          msg = self.tx_queue.get_nowait()
                      except queue.Empty:
                          break

                      dst = msg['dst']
                      data = msg.get('data', b'')
                      pkt_type = msg.get('type', self.PKT_DATA)

                      # Assign sequence number
                      seq = self.seq_num_tx
                      self.seq_num_tx = (self.seq_num_tx + 1) % 256

                      packet = self.create_packet(dst, seq, pkt_type, data)

                      # For broadcast we typically don't do ARQ; transmit once and don't put in window
                      if dst == 0xFF or pkt_type != self.PKT_DATA:
                          print(f"[Node {self.node_id}] TX (no ARQ): seq={seq} dst={dst}")
                          self.send_with_aloha(packet)
                          self.stats['packets_sent'] += 1
                          continue

                      # Reliable (GBN-managed) packet
                      is_new_window = (len(self.tx_window) == 0)

                      self.tx_window[seq] = {
                          'packet': packet,
                          'feedback_sent': False,
                      }

                      # If this is the first packet of a new window, send a sync burst first
                      if is_new_window:
                          self.send_sync_burst()

                      print(f"[Node {self.node_id}] TX: Sending DATA seq={seq} dst={dst} (window size={len(self.tx_window)})")
                      self.send_with_aloha(packet)
                      self.stats['packets_sent'] += 1

                      # If this is the first packet in window, start timer
                      if len(self.tx_window) == 1:
                          self.window_timer_start = time.time()
                          self.window_retries = 0

              except Exception as e:
                  print(f"[Node {self.node_id}] Error filling window: {e}")

          def check_window_timeout(self):
              """Check for Go-Back-N timeout on the base of the window and retransmit if needed."""
              if not self.tx_window:
                  return

              if self.window_timer_start is None:
                  return

              now = time.time()
              if now - self.window_timer_start < self.timeout:
                  return

              # Timeout occurred for base of window
              self.stats['window_timeouts'] += 1
              self.window_retries += 1
              base_seq = next(iter(self.tx_window.keys()))
              print(f"[Node {self.node_id}] GBN timeout at seq={base_seq}, retry {self.window_retries}/{self.max_retries}")

              if self.window_retries > self.max_retries:
                  print(f"[Node {self.node_id}] GBN: Max retries exceeded, dropping window")
                  # Mark all outstanding packets as failed
                  for _seq, entry in list(self.tx_window.items()):
                      if not entry.get('feedback_sent', False):
                          self.send_feedback(False)
                          entry['feedback_sent'] = True
                  self.tx_window.clear()
                  self.window_timer_start = None
                  self.window_retries = 0
                  return

              # Go-Back-N: retransmit all packets currently in the window
              for seq, entry in self.tx_window.items():
                  print(f"[Node {self.node_id}] GBN retransmit seq={seq}")
                  self.send_with_aloha(entry['packet'])
                  self.stats['retransmissions'] += 1

              # Restart timer for the base
              self.window_timer_start = time.time()

          def tx_handler(self):
              """Thread for handling Go-Back-N transmission + ALOHA medium access."""
              while self.running:
                  try:
                      # 1) Process all ACKs
                      self.process_acks()

                      # 2) Check for timeout on window base
                      self.check_window_timeout()

                      # 3) Fill window with new packets from tx_queue if space
                      self.fill_window_from_queue()

                      # Small sleep to avoid busy-wait
                      time.sleep(0.01)

                  except Exception as e:
                      print(f"[Node {self.node_id}] TX handler error: {e}")

          # -------------------------------------------------------------------------
          # RX thread (packetization + GBN receiver side)
          # -------------------------------------------------------------------------
          def rx_handler(self):
              """Thread for handling packet reception and GBN RX logic."""
              while self.running:
                  try:
                      try:
                          rx_data = self.rx_queue.get(timeout=0.1)
                      except queue.Empty:
                          continue

                      # Append to RX buffer
                      self.rx_buffer += rx_data

                      # Extract packets from buffer
                      while len(self.rx_buffer) > 0:
                          pkt = self.parse_packet(self.rx_buffer)

                          if pkt is None:
                              # No valid packet at current alignment; drop one byte and re-try
                              if len(self.rx_buffer) > 1:
                                  self.rx_buffer = self.rx_buffer[1:]
                              else:
                                  self.rx_buffer = bytes()
                              continue

                          # Remove processed bytes
                          self.rx_buffer = self.rx_buffer[pkt['consumed']:]

                          # Addressing: packet must be for us or broadcast
                          if pkt['dst'] != self.node_id and pkt['dst'] != 0xFF:
                              print(f"[Node {self.node_id}] RX: Packet not for us (dst={pkt['dst']})")
                              continue

                          if pkt['type'] == self.PKT_DATA:
                              self.handle_data_packet(pkt)
                          elif pkt['type'] == self.PKT_ACK:
                              self.handle_ack_packet(pkt)

                  except Exception as e:
                      print(f"[Node {self.node_id}] RX handler error: {e}")

          def handle_data_packet(self, pkt):
              """Handle incoming DATA packet with GBN receiver logic."""
              src = pkt['src']
              seq = pkt['seq']
              payload = pkt['payload']

              self.stats['packets_received'] += 1
              expected = self.expected_seq_rx.get(src, 0)

              if seq == expected:
                  # In-order packet: accept and advance
                  print(f"[Node {self.node_id}] RX: In-order DATA from {src}, seq={seq} (expected={expected})")
                  self.expected_seq_rx[src] = (expected + 1) % 256
                  ack_seq = seq
                  is_new = True
              else:
                  # Out-of-order or duplicate
                  print(f"[Node {self.node_id}] RX: Out-of-order/dup DATA from {src}, seq={seq}, expected={expected}")
                  # Last correctly received in-order seq is expected-1 (mod 256)
                  if expected == 0:
                      ack_seq = 255
                  else:
                      ack_seq = (expected - 1) & 0xFF
                  is_new = False

              # Send ACK for last in-order seq (GBN cumulative ACK)
              ack_packet = self.create_packet(src, ack_seq, self.PKT_ACK)
              print(f"[Node {self.node_id}] RX: Sending ACK seq={ack_seq} to {src}")
              self.send_with_aloha(ack_packet)
              self.stats['acks_sent'] += 1

              # Deliver only new, in-order packets to the application
              if is_new:
                  self.forward_to_app(src, payload)

          def handle_ack_packet(self, pkt):
              """Handle incoming ACK packet (push to ack_queue for TX thread)."""
              src = pkt['src']
              seq = pkt['seq']
              print(f"[Node {self.node_id}] RX: ACK from node {src}, seq={seq}")
              # Push seq to ack queue; TX thread handles window sliding
              self.ack_queue.put({'src': src, 'seq': seq})

          # -------------------------------------------------------------------------
          # Upper-layer delivery & feedback
          # -------------------------------------------------------------------------
          def forward_to_app(self, src_id, data):
              """Forward received data to application/GUI."""
              try:
                  message = data.decode('utf-8', errors='ignore')
                  output = f"[From Node {src_id}]: {message}"

                  # Simple string out
                  msg = pmt.intern(output)
                  self.message_port_pub(self.port_msg_out, msg)

                  # (Optional) could also send a dict PDU here if needed
                  print(f"[Node {self.node_id}] Message delivered: {output}")

              except Exception as e:
                  print(f"[Node {self.node_id}] Error forwarding to app: {e}")

          def send_feedback(self, success):
              """Send boolean-like feedback (TRUE/FALSE) to feedback port."""
              try:
                  text = "TRUE" if success else "FALSE"
                  msg = pmt.intern(text)
                  self.message_port_pub(self.port_feedback, msg)
              except Exception as e:
                  print(f"[Node {self.node_id}] Error sending feedback: {e}")

          # -------------------------------------------------------------------------
          # GNU Radio boilerplate
          # -------------------------------------------------------------------------
          def work(self, input_items, output_items):
              """Main work function (not used for message-passing block)."""
              return 0

          def stop(self):
              """Clean shutdown"""
              print(f"\n[Node {self.node_id}] Statistics:")
              print(f"  Packets sent:      {self.stats['packets_sent']}")
              print(f"  Packets received:  {self.stats['packets_received']}")
              print(f"  ACKs sent:         {self.stats['acks_sent']}")
              print(f"  ACKs received:     {self.stats['acks_received']}")
              print(f"  Retransmissions:   {self.stats['retransmissions']}")
              print(f"  CRC errors:        {self.stats['crc_errors']}")
              print(f"  Window timeouts:   {self.stats['window_timeouts']}")

              self.running = False
              if self.tx_thread.is_alive():
                  self.tx_thread.join()
              if self.rx_thread.is_alive():
                  self.rx_thread.join()
              return True
    aloha_backoff_max: '0.5'
    aloha_backoff_min: '0.1'
    aloha_prob: '0.3'
    max_retries: '3'
    node_id: '2'
    sync_burst_len: '1000'
    timeout: '1.0'
    window_size: '4'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency Spectrum of Tx
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency Spectrum of Tx
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    name: RX-SPECTRUM of ACK
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    name: RX-SPECTRUM of ACK
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: 1.2e9
    gain: '50'
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: 1.2e9
    gain: '50'
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: 5.8e9
    gain: '30.0'
    samp_rate: samp_rate*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: 5.8e9
    gain: '30.0'
    samp_rate: samp_rate*2
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: to_user_2
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_tx_2
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ACK
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: ACK_2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: to_user_1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: channel_tx_2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: to_user_2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ACK
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: ACK_2
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: to_user_1
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', virtual_sink_1, '0']
- [blocks_repack_bits_bb_1_0_0, '0', virtual_sink_1_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [channels_channel_model_0_0, '0', virtual_sink_2, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [digital_linear_equalizer_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0_0_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', digital_linear_equalizer_0_0_0_0, '0']
- [epy_block_0_1, out, epy_block_1_0, msg_in]
- [epy_block_0_1, out, epy_block_1_0_0_0, msg_in]
- [epy_block_0_1_0, out, epy_block_1_0_0, msg_in]
- [epy_block_0_1_0, out, epy_block_1_0_0_1, msg_in]
- [epy_block_1_0, feedback, epy_block_0_1, feedback]
- [epy_block_1_0, msg_out, epy_block_0_1, in_msg]
- [epy_block_1_0, pdu_out, digital_protocol_formatter_async_0, in]
- [epy_block_1_0_0, feedback, epy_block_0_1_0, feedback]
- [epy_block_1_0_0, msg_out, epy_block_0_1_0, in_msg]
- [epy_block_1_0_0, pdu_out, digital_protocol_formatter_async_0_0, in]
- [epy_block_1_0_0_0, feedback, epy_block_0_1, feedback]
- [epy_block_1_0_0_0, msg_out, epy_block_0_1, in_msg]
- [epy_block_1_0_0_0, pdu_out, digital_protocol_formatter_async_0, in]
- [epy_block_1_0_0_1, feedback, epy_block_0_1_0, feedback]
- [epy_block_1_0_0_1, msg_out, epy_block_0_1_0, in_msg]
- [epy_block_1_0_0_1, pdu_out, digital_protocol_formatter_async_0_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_1_0, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_1_0_0_0, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, epy_block_1_0_0, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, epy_block_1_0_0_1, pdu_in]
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [soapy_bladerf_source_0_0, '0', qtgui_const_sink_x_0, '0']
- [soapy_bladerf_source_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [soapy_bladerf_source_0_0_0, '0', digital_symbol_sync_xx_0_0_0, '0']
- [soapy_bladerf_source_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [soapy_bladerf_source_0_0_0, '0', qtgui_freq_sink_x_1_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0_0, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_1, '0', digital_symbol_sync_xx_0_0_0, '0']
- [virtual_source_1, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_1_0_0, '0']
- [virtual_source_2, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [virtual_source_2_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [virtual_source_3, '0', digital_symbol_sync_xx_0_0, '0']
- [virtual_source_3, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_3, '0', qtgui_freq_sink_x_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
