options:
  parameters:
    author: Barry Duggan
    description: TX / RX loopback
    generate_options: qt_gui
    id: loopback_test
    output_language: python
    title: loopback_test
  states: {}

blocks:
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample rate
    num_opts: '2'
    option0: '768000'
    option1: '576000'
    type: int
    value: '768000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_throttle2_0, '0', zeromq_pub_sink_0, '0']
- [low_pass_filter_0, '0', blocks_throttle2_0, '0']
- [zeromq_sub_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
