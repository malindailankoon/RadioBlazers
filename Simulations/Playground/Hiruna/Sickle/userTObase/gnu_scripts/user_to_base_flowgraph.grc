options:
  parameters:
    author: malindatemp
    generate_options: qt_gui
    id: user_to_base_flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: ConFile
  id: parameter
  parameters:
    label: the confirm.txt file
    type: str
    value: default
  states: {}
- name: MsgFile
  id: parameter
  parameters:
    label: the packet file
    type: str
    value: default
  states: {state: disabled}
- name: RnFile
  id: parameter
  parameters:
    label: the packet file
    type: str
    value: default
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\immkb\Desktop\semester_3\communication_design_project\sickle\userTObase\rec_side_stuff\misc\output.tmp
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os.path
      import pmt







      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, confirm_file = 'None', request_number_file = 'None'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='User side transmitter block',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.confirm_file = confirm_file
              self.request_number_file = request_number_file
              self.state = 0
              self.user_address = "11"
              self.request_num = None
              self.indx = 0

          def headify(self, bits):
              return self.user_address + bits
          
          def CRC_adder(self, bits):
              poly = 0x104C11DB7
              data = int(bits, 2)
              data <<= 32
              poly_length = poly.bit_length()
              while data.bit_length() >= poly_length:
                  data ^= poly << (data.bit_length() - poly_length)
              crc_bits = format(data, "032b")
              return bits + crc_bits




          def work(self, input_items, output_items):
              
              if (self.state == 0):
                  if (os.path.exists(self.confirm_file)):
                      with open(self.confirm_file, "r") as confirm_file:
                          c = confirm_file.read().strip()
                          if (c == "True"):
                              if (os.path.exists(self.request_number_file)):
                                  with open(self.request_number_file , "r") as req_num_file:
                                      self.request_num = int(req_num_file.read().strip())
                                      self.state = 1
                              else:
                                  self.state = 7
                                  print("the request number file did not exist")
                          else:
                              self.state = 0
                  else:
                      self.state = 7
                      print("the confirm file did not exist")
                  return (0)
              
              if (self.state == 1): 
                  req_num_bits = format(self.request_num, "06b")
                  headed_msg = self.headify(req_num_bits)
                  final_msg = self.CRC_adder(headed_msg)

                  msg_bytes = np.packbits(np.frombuffer(final_msg.encode("ascii"), dtype=np.uint8) - 48) # [43 65 34 34 23 23 54 23]
                  msg_len = len(msg_bytes)

                  key0 = pmt.intern("packet_len")
                  val0 = pmt.from_long(msg_len)
                  self.add_item_tag(0,
                                    self.indx,
                                    key0,
                                    val0,
                                    )
                  self.indx += msg_len


                  i=0
                  while (i < msg_len):
                      output_items[0][i] = msg_bytes[i]
                      i += 1
                  
                  self.state = 0

                  if (os.path.exists(self.confirm_file)):
                      with open(self.confirm_file, "w") as con_file:
                          con_file.write("False")


                  return (msg_len)




              
              
              # output_items[0][:] = input_items[0] * self.example_param
              # return len(output_items[0])
    confirm_file: ConFile
    request_number_file: RnFile
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport os.path\n\nfolder = \"D:/Academics/Semester 3/CDP/Repo/Simulations/Playground/Hiruna/Sickle\"\n\nstate = 0\naddr = \"11\"\n\nrequest_file = os.path.join(folder, \"userTObase\", \"rec_side_stuff\", \"misc\", \"req_num.txt\")\nconfirm_file = os.path.join(folder, \"userTObase\", \"rec_side_stuff\", \"misc\", \"confirm.txt\")\n\n\n\ndef crc_generator(bits):\n    poly = 0x104C11DB7\n\n    data = int(bits, 2)\n\n    data <<= 32\n\n    poly_length = poly.bit_length()\n\n    while data.bit_length() >= poly_length:\n        data ^= poly << (data.bit_length() - poly_length)\n    \n    crc_bits = format(data, \"032b\")\n\n    return crc_bits\n\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \n        gr.sync_block.__init__(\n            self,\n            name='ack receiver block',   # will show up in GRC\n            in_sig=[np.uint8],\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.buffer = bytearray()\n\n\n\n    def work(self, input_items, output_items):\n        \n        in_bytes = input_items[0]\n\n        self.buffer.extend(in_bytes)\n\n        print(\"bytes: \", in_bytes)\n\n\n        while len(self.buffer) >= 5:\n            msg = self.buffer[:5]\n            self.buffer = self.buffer[5:]\n\n            bit_str = ''.join(f\"{b:08b}\" for b in msg)\n\n            doTheThing(bit_str)\n\n            bit_str = ''\n\n        return len(in_bytes)\n\n\n\n\n\n\ndef doTheThing(bit_str):\n    \n    header_string = bit_str[:8]\n\n    if int(crc_generator(bit_str)) != 0:\n        print('CRC failed')\n        return\n    else:\n        print('CRC successful')\n\n        rx_addr = header_string[:2]\n        rx_seq = header_string[2:8]\n\n        if rx_addr != addr:\n            print(\"incorrect address\")\n            return \n        \n        request_number = rx_seq\n\n        with open(request_file, \"w\") as req_file:\n            req_file.write(str(request_number))\n        \n        with open(confirm_file, \"w\") as con_file:\n            con_file.write(\"True\")\n\n        \n\n\n\n\n\n\n\n"
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}

connections:
- [blocks_repack_bits_bb_1, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_1, '0', epy_block_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0_0_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_constellation_decoder_cb_0_1, '0', digital_diff_decoder_bb_0_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_costas_loop_cc_0_1, '0', digital_constellation_decoder_cb_0_1, '0']
- [digital_diff_decoder_bb_0_1, '0', digital_map_bb_0_1, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_1, '0']
- [digital_map_bb_0_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_0, '0', blocks_tagged_stream_mux_0, '1']
- [epy_block_0, '0', digital_protocol_formatter_bb_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_0_0_0, '0', digital_costas_loop_cc_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
