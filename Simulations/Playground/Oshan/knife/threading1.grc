options:
  parameters:
    generate_options: qt_gui
    id: threading1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''101010101010101010101010101010100010110111010100'''
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("2:Hello from A")
    period: '1000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("1:Hello from B")
    period: '1000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block for GNU Radio - Mesh Network Packet Communication
      Implements packetization, Stop-and-Wait ARQ, and ALOHA collision avoidance
      No external CRC module required - implements CRC-16 CCITT manually
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import queue
      import time
      import random
      import struct

      class blk(gr.sync_block):
          """
          Mesh Network Packet Communication Block
          Handles packet transmission/reception with Stop-and-Wait ARQ
          """
          
          def __init__(self, node_id=1, aloha_prob=0.3, timeout=1.0, max_retries=3):
              """
              Arguments:
                  node_id: Unique identifier for this node (1-255)
                  aloha_prob: Transmission probability for ALOHA (0.0-1.0)
                  timeout: ARQ timeout in seconds
                  max_retries: Maximum retransmission attempts
              """
              gr.sync_block.__init__(
                  self,
                  name='Mesh Packet Comm',
                  in_sig=None,
                  out_sig=None
              )
              
              # Node configuration
              self.node_id = node_id
              self.aloha_prob = aloha_prob
              self.timeout = timeout
              self.max_retries = max_retries
              
              # Packet parameters
              self.PREAMBLE = bytes([0xAA, 0xAA, 0xAA, 0xAA])
              self.SYNC_WORD = bytes([0x2D, 0xD4])
              self.MAX_PAYLOAD = 255
              self.HEADER_SIZE = 8  # preamble(4) + sync(2) + src(1) + dst(1)
              self.CRC_SIZE = 2
              
              # Packet types
              self.PKT_DATA = 0x01
              self.PKT_ACK = 0x02
              
              # CRC-16 CCITT lookup table
              self.crc_table = self.generate_crc_table()
              
              # State management
              self.tx_queue = queue.Queue()
              self.rx_queue = queue.Queue()
              self.ack_queue = queue.Queue()
              self.pending_ack = {}
              self.seq_num_tx = 0
              self.seq_num_rx = {}
              self.rx_buffer = bytes()
              
              # Statistics
              self.stats = {
                  'packets_sent': 0,
                  'packets_received': 0,
                  'acks_sent': 0,
                  'acks_received': 0,
                  'retransmissions': 0,
                  'crc_errors': 0
              }
              
              # Threading
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_handler)
              self.rx_thread = threading.Thread(target=self.rx_handler)
              self.lock = threading.Lock()
              
              # Message ports
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              
              # Set message handlers
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg_in)
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu_in)
              
              # Start threads
              self.tx_thread.start()
              self.rx_thread.start()
              
              print(f"[Node {self.node_id}] Initialized - Ready for communication")
          
          def generate_crc_table(self):
              """Generate CRC-16 CCITT lookup table"""
              poly = 0x1021
              table = []
              for i in range(256):
                  crc = i << 8
                  for j in range(8):
                      if crc & 0x8000:
                          crc = ((crc << 1) ^ poly) & 0xFFFF
                      else:
                          crc = (crc << 1) & 0xFFFF
                  table.append(crc)
              return table
          
          def calculate_crc16(self, data):
              """Calculate CRC-16 CCITT for given data"""
              crc = 0xFFFF
              for byte in data:
                  tbl_idx = ((crc >> 8) ^ byte) & 0xFF
                  crc = ((crc << 8) ^ self.crc_table[tbl_idx]) & 0xFFFF
              return crc
          
          def handle_msg_in(self, msg):
              """Handle incoming messages from GUI/application"""
              try:
                  # Handle string messages directly
                  if pmt.is_symbol(msg):
                      # Simple text message format: "dst_id:message"
                      text = pmt.symbol_to_string(msg)
                      if ':' in text:
                          parts = text.split(':', 1)
                          try:
                              dst_id = int(parts[0])
                              data = parts[1].encode()
                              self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                              print(f"[Node {self.node_id}] Queued message to {dst_id}: {parts[1]}")
                          except ValueError:
                              print(f"[Node {self.node_id}] Invalid destination ID")
                  
                  # Handle dictionary messages
                  elif pmt.is_dict(msg):
                      meta = pmt.to_python(msg)
                      if 'dst' in meta and 'data' in meta:
                          dst_id = meta['dst']
                          data = meta['data'].encode() if isinstance(meta['data'], str) else meta['data']
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued message to {dst_id}")
                  
                  # Handle pair messages (PDU format)
                  elif pmt.is_pair(msg):
                      meta = pmt.to_python(pmt.car(msg))
                      data = pmt.to_python(pmt.cdr(msg))
                      if isinstance(meta, dict) and 'dst' in meta:
                          dst_id = meta['dst']
                          if isinstance(data, str):
                              data = data.encode()
                          elif isinstance(data, list):
                              data = bytes(data)
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued message to {dst_id}")
                          
              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling msg_in: {e}")
          
          def handle_pdu_in(self, pdu):
              """Handle incoming PDUs from demodulator"""
              try:
                  # Extract PDU data
                  if pmt.is_pair(pdu):
                      meta = pmt.car(pdu)
                      data = pmt.cdr(pdu)
                      
                      # Convert to bytes
                      if pmt.is_u8vector(data):
                          print("loop run")	
                          rx_bytes = bytes(pmt.u8vector_elements(data))	
                          self.rx_queue.put(rx_bytes)
                      elif pmt.is_uniform_vector(data):
                          # Handle float32 or other vector types
                          elements = pmt.to_python(data)
                          # Convert to bytes (assuming 8-bit symbols)
                          rx_bytes = bytes([int(x) & 0xFF for x in elements])
                          self.rx_queue.put(rx_bytes)
                          
              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling pdu_in: {e}")
          
          def create_packet(self, dst_id, seq_num, pkt_type, payload=b''):
              """Create a packet with headers and CRC"""
              packet = bytearray()
              
              # Add preamble and sync word
              packet.extend(self.PREAMBLE)
              packet.extend(self.SYNC_WORD)
              
              # Add header
              packet.append(self.node_id)  # Source ID
              packet.append(dst_id)         # Destination ID
              packet.append(seq_num)        # Sequence number
              packet.append(pkt_type)       # Packet type
              packet.append(len(payload))   # Payload length
              
              # Add payload
              if payload:
                  packet.extend(payload[:self.MAX_PAYLOAD])
              
              # Calculate and add CRC16
              crc_data = bytes(packet[len(self.PREAMBLE) + len(self.SYNC_WORD):])
              crc_val = self.calculate_crc16(crc_data)
              packet.extend(struct.pack('>H', crc_val))
              
              return bytes(packet)
          
          def parse_packet(self, data):
              """Parse received packet and validate CRC"""
              try:
                  # Find sync word
                  sync_idx = data.find(self.SYNC_WORD)
                  if sync_idx == -1:
                      return None
                  
                  # Check minimum packet size
                  start_idx = sync_idx + len(self.SYNC_WORD)
                  if len(data) < start_idx + 5 + self.CRC_SIZE:
                      return None
                  
                  # Extract header fields
                  src_id = data[start_idx]
                  dst_id = data[start_idx + 1]
                  seq_num = data[start_idx + 2]
                  pkt_type = data[start_idx + 3]
                  payload_len = data[start_idx + 4]
                  
                  # Check if we have complete packet
                  total_len = start_idx + 5 + payload_len + self.CRC_SIZE
                  if len(data) < total_len:
                      return None
                  
                  # Extract payload and CRC
                  payload = data[start_idx + 5:start_idx + 5 + payload_len]
                  rx_crc = struct.unpack('>H', data[total_len - self.CRC_SIZE:total_len])[0]
                  
                  # Verify CRC
                  crc_data = data[start_idx:total_len - self.CRC_SIZE]
                  calc_crc = self.calculate_crc16(crc_data)
                  
                  if rx_crc != calc_crc:
                      self.stats['crc_errors'] += 1
                      print(f"[Node {self.node_id}] CRC mismatch (expected: {calc_crc:04X}, got: {rx_crc:04X})")
                      return None
                  
                  return {
                      'src': src_id,
                      'dst': dst_id,
                      'seq': seq_num,
                      'type': pkt_type,
                      'payload': payload,
                      'consumed': total_len
                  }
              except Exception as e:
                  print(f"[Node {self.node_id}] Error parsing packet: {e}")
                  return None
          
          def tx_handler(self):
              """Thread for handling packet transmission with ARQ"""
              while self.running:
                  try:
                      # Get message from queue (with timeout for thread safety)
                      try:
                          msg = self.tx_queue.get(timeout=0.1)
                      except queue.Empty:
                          continue
                      
                      # ALOHA: Random backoff
                      if random.random() > self.aloha_prob:
                          backoff_time = random.uniform(0.1, 0.5)
                          print(f"[Node {self.node_id}] ALOHA backoff {backoff_time:.2f}s")
                          time.sleep(backoff_time)
                          # Re-queue the message
                          self.tx_queue.put(msg)
                          continue
                      
                      # Prepare packet
                      with self.lock:
                          seq_num = self.seq_num_tx
                          self.seq_num_tx = (self.seq_num_tx + 1) % 256
                      
                      packet = self.create_packet(
                          msg['dst'],
                          seq_num,
                          msg['type'],
                          msg.get('data', b'')
                      )
                      
                      # Stop-and-Wait ARQ
                      retries = 0
                      ack_received = False
                      
                      while retries < self.max_retries and not ack_received:
                          # Transmit packet
                          print(f"[Node {self.node_id}] TX: Sending packet seq={seq_num} to node {msg['dst']} (attempt {retries + 1})")
                          self.transmit_packet(packet)
                          self.stats['packets_sent'] += 1
                          
                          if retries > 0:
                              self.stats['retransmissions'] += 1
                          
                          # Wait for ACK
                          ack_key = f"{msg['dst']}_{seq_num}"
                          timeout_time = time.time() + self.timeout
                          
                          while time.time() < timeout_time:
                              try:
                                  ack = self.ack_queue.get(timeout=0.1)
                                  if ack['key'] == ack_key:
                                      ack_received = True
                                      self.stats['acks_received'] += 1
                                      print(f"[Node {self.node_id}] TX: ACK received for seq={seq_num}")
                                      break
                              except queue.Empty:
                                  pass
                          
                          if not ack_received:
                              retries += 1
                              if retries < self.max_retries:
                                  print(f"[Node {self.node_id}] TX: Timeout, retry {retries}/{self.max_retries}")
                      
                      if not ack_received:
                          print(f"[Node {self.node_id}] TX: Failed to deliver packet seq={seq_num} after {self.max_retries} attempts")
                          
                  except Exception as e:
                      print(f"[Node {self.node_id}] TX handler error: {e}")
          
          def rx_handler(self):
              """Thread for handling packet reception"""
              while self.running:
                  try:
                      # Get received data
                      try:
                          rx_data = self.rx_queue.get(timeout=0.1)
                      except queue.Empty:
                          continue
                      
                      # Add to buffer
                      self.rx_buffer += rx_data
                      
                      # Try to parse packets from buffer
                      while len(self.rx_buffer) > 0:
                          pkt = self.parse_packet(self.rx_buffer)
                          
                          if pkt is None:
                              # No valid packet found, remove first byte and try again
                              if len(self.rx_buffer) > 1:
                                  self.rx_buffer = self.rx_buffer[1:]
                              else:
                                  self.rx_buffer = bytes()
                              continue
                          
                          # Remove processed packet from buffer
                          self.rx_buffer = self.rx_buffer[pkt['consumed']:]
                          
                          # Check if packet is for this node or broadcast
                          if pkt['dst'] != self.node_id and pkt['dst'] != 0xFF:
                              print(f"[Node {self.node_id}] RX: Packet not for us (dst={pkt['dst']})")
                              continue
                          
                          # Handle based on packet type
                          if pkt['type'] == self.PKT_DATA:
                              self.stats['packets_received'] += 1
                              print(f"[Node {self.node_id}] RX: Data packet from node {pkt['src']}, seq={pkt['seq']}")
                              
                              # Check for duplicate
                              is_duplicate = False
                              if pkt['src'] in self.seq_num_rx:
                                  if self.seq_num_rx[pkt['src']] == pkt['seq']:
                                      print(f"[Node {self.node_id}] RX: Duplicate packet detected")
                                      is_duplicate = True
                              
                              self.seq_num_rx[pkt['src']] = pkt['seq']
                              
                              # Send ACK
                              ack_packet = self.create_packet(
                                  pkt['src'],
                                  pkt['seq'],
                                  self.PKT_ACK
                              )
                              print(f"[Node {self.node_id}] RX: Sending ACK for seq={pkt['seq']}")
                              self.transmit_packet(ack_packet)
                              self.stats['acks_sent'] += 1
                              
                              # Forward to application if not duplicate
                              if not is_duplicate:
                                  self.forward_to_app(pkt['src'], pkt['payload'])
                              
                          elif pkt['type'] == self.PKT_ACK:
                              print(f"[Node {self.node_id}] RX: ACK packet from node {pkt['src']}, seq={pkt['seq']}")
                              # Process ACK
                              ack_key = f"{pkt['src']}_{pkt['seq']}"
                              self.ack_queue.put({'key': ack_key})
                              
                  except Exception as e:
                      print(f"[Node {self.node_id}] RX handler error: {e}")
          
          def transmit_packet(self, packet):
              """Send packet to physical layer"""
              try:
                  # Convert to PDU format
                  vec = pmt.init_u8vector(len(packet), list(packet))
                  pdu = pmt.cons(pmt.PMT_NIL, vec)
                  
                  # Send to modulator
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)
                  
              except Exception as e:
                  print(f"[Node {self.node_id}] Error transmitting packet: {e}")
          
          def forward_to_app(self, src_id, data):
              """Forward received data to application/GUI"""
              try:
                  # Decode message
                  message = data.decode('utf-8', errors='ignore')
                  
                  # Create formatted output string
                  output = f"[From Node {src_id}]: {message}"
                  
                  # Send as simple string message
                  msg = pmt.intern(output)
                  self.message_port_pub(pmt.intern('msg_out'), msg)
                  
                  # Also send as dictionary for more complex processing
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("src"), pmt.from_long(src_id))
                  meta = pmt.dict_add(meta, pmt.intern("data"), pmt.intern(message))
                  
                  print(f"[Node {self.node_id}] Message delivered: {output}")
                  
              except Exception as e:
                  print(f"[Node {self.node_id}] Error forwarding to app: {e}")
          
          def work(self, input_items, output_items):
              """Main work function (not used for message passing blocks)"""
              return 0
          
          def stop(self):
              """Clean shutdown"""
              print(f"\n[Node {self.node_id}] Statistics:")
              print(f"  Packets sent: {self.stats['packets_sent']}")
              print(f"  Packets received: {self.stats['packets_received']}")
              print(f"  ACKs sent: {self.stats['acks_sent']}")
              print(f"  ACKs received: {self.stats['acks_received']}")
              print(f"  Retransmissions: {self.stats['retransmissions']}")
              print(f"  CRC errors: {self.stats['crc_errors']}")
              
              self.running = False
              if self.tx_thread.is_alive():
                  self.tx_thread.join()
              if self.rx_thread.is_alive():
                  self.rx_thread.join()
              return True
    aloha_prob: '0.5'
    max_retries: '3'
    node_id: '1'
    timeout: '1'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block for GNU Radio - Mesh Network Packet Communication
      Implements packetization, Stop-and-Wait ARQ, and ALOHA collision avoidance
      No external CRC module required - implements CRC-16 CCITT manually
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import queue
      import time
      import random
      import struct

      class blk(gr.sync_block):
          """
          Mesh Network Packet Communication Block
          Handles packet transmission/reception with Stop-and-Wait ARQ
          """
          
          def __init__(self, node_id=1, aloha_prob=0.3, timeout=1.0, max_retries=3):
              """
              Arguments:
                  node_id: Unique identifier for this node (1-255)
                  aloha_prob: Transmission probability for ALOHA (0.0-1.0)
                  timeout: ARQ timeout in seconds
                  max_retries: Maximum retransmission attempts
              """
              gr.sync_block.__init__(
                  self,
                  name='Mesh Packet Comm',
                  in_sig=None,
                  out_sig=None
              )
              
              # Node configuration
              self.node_id = node_id
              self.aloha_prob = aloha_prob
              self.timeout = timeout
              self.max_retries = max_retries
              
              # Packet parameters
              self.PREAMBLE = bytes([0xAA, 0xAA, 0xAA, 0xAA])
              self.SYNC_WORD = bytes([0x2D, 0xD4])
              self.MAX_PAYLOAD = 255
              self.HEADER_SIZE = 8  # preamble(4) + sync(2) + src(1) + dst(1)
              self.CRC_SIZE = 2
              
              # Packet types
              self.PKT_DATA = 0x01
              self.PKT_ACK = 0x02
              
              # CRC-16 CCITT lookup table
              self.crc_table = self.generate_crc_table()
              
              # State management
              self.tx_queue = queue.Queue()
              self.rx_queue = queue.Queue()
              self.ack_queue = queue.Queue()
              self.pending_ack = {}
              self.seq_num_tx = 0
              self.seq_num_rx = {}
              self.rx_buffer = bytes()
              
              # Statistics
              self.stats = {
                  'packets_sent': 0,
                  'packets_received': 0,
                  'acks_sent': 0,
                  'acks_received': 0,
                  'retransmissions': 0,
                  'crc_errors': 0
              }
              
              # Threading
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_handler)
              self.rx_thread = threading.Thread(target=self.rx_handler)
              self.lock = threading.Lock()
              
              # Message ports
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              
              # Set message handlers
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg_in)
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu_in)
              
              # Start threads
              self.tx_thread.start()
              self.rx_thread.start()
              
              print(f"[Node {self.node_id}] Initialized - Ready for communication")
          
          def generate_crc_table(self):
              """Generate CRC-16 CCITT lookup table"""
              poly = 0x1021
              table = []
              for i in range(256):
                  crc = i << 8
                  for j in range(8):
                      if crc & 0x8000:
                          crc = ((crc << 1) ^ poly) & 0xFFFF
                      else:
                          crc = (crc << 1) & 0xFFFF
                  table.append(crc)
              return table
          
          def calculate_crc16(self, data):
              """Calculate CRC-16 CCITT for given data"""
              crc = 0xFFFF
              for byte in data:
                  tbl_idx = ((crc >> 8) ^ byte) & 0xFF
                  crc = ((crc << 8) ^ self.crc_table[tbl_idx]) & 0xFFFF
              return crc
          
          def handle_msg_in(self, msg):
              """Handle incoming messages from GUI/application"""
              try:
                  # Handle string messages directly
                  if pmt.is_symbol(msg):
                      # Simple text message format: "dst_id:message"
                      text = pmt.symbol_to_string(msg)
                      if ':' in text:
                          parts = text.split(':', 1)
                          try:
                              dst_id = int(parts[0])
                              data = parts[1].encode()
                              self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                              print(f"[Node {self.node_id}] Queued message to {dst_id}: {parts[1]}")
                          except ValueError:
                              print(f"[Node {self.node_id}] Invalid destination ID")
                  
                  # Handle dictionary messages
                  elif pmt.is_dict(msg):
                      meta = pmt.to_python(msg)
                      if 'dst' in meta and 'data' in meta:
                          dst_id = meta['dst']
                          data = meta['data'].encode() if isinstance(meta['data'], str) else meta['data']
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued message to {dst_id}")
                  
                  # Handle pair messages (PDU format)
                  elif pmt.is_pair(msg):
                      meta = pmt.to_python(pmt.car(msg))
                      data = pmt.to_python(pmt.cdr(msg))
                      if isinstance(meta, dict) and 'dst' in meta:
                          dst_id = meta['dst']
                          if isinstance(data, str):
                              data = data.encode()
                          elif isinstance(data, list):
                              data = bytes(data)
                          self.tx_queue.put({'dst': dst_id, 'data': data, 'type': self.PKT_DATA})
                          print(f"[Node {self.node_id}] Queued message to {dst_id}")
                          
              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling msg_in: {e}")
          
          def handle_pdu_in(self, pdu):
              """Handle incoming PDUs from demodulator"""
              try:
                  # Extract PDU data
                  if pmt.is_pair(pdu):
                      meta = pmt.car(pdu)
                      data = pmt.cdr(pdu)
                      
                      # Convert to bytes
                      if pmt.is_u8vector(data):
                          print("loop run")	
                          rx_bytes = bytes(pmt.u8vector_elements(data))	
                          self.rx_queue.put(rx_bytes)
                      elif pmt.is_uniform_vector(data):
                          # Handle float32 or other vector types
                          elements = pmt.to_python(data)
                          # Convert to bytes (assuming 8-bit symbols)
                          rx_bytes = bytes([int(x) & 0xFF for x in elements])
                          self.rx_queue.put(rx_bytes)
                          
              except Exception as e:
                  print(f"[Node {self.node_id}] Error handling pdu_in: {e}")
          
          def create_packet(self, dst_id, seq_num, pkt_type, payload=b''):
              """Create a packet with headers and CRC"""
              packet = bytearray()
              
              # Add preamble and sync word
              packet.extend(self.PREAMBLE)
              packet.extend(self.SYNC_WORD)
              
              # Add header
              packet.append(self.node_id)  # Source ID
              packet.append(dst_id)         # Destination ID
              packet.append(seq_num)        # Sequence number
              packet.append(pkt_type)       # Packet type
              packet.append(len(payload))   # Payload length
              
              # Add payload
              if payload:
                  packet.extend(payload[:self.MAX_PAYLOAD])
              
              # Calculate and add CRC16
              crc_data = bytes(packet[len(self.PREAMBLE) + len(self.SYNC_WORD):])
              crc_val = self.calculate_crc16(crc_data)
              packet.extend(struct.pack('>H', crc_val))
              
              return bytes(packet)
          
          def parse_packet(self, data):
              """Parse received packet and validate CRC"""
              try:
                  # Find sync word
                  sync_idx = data.find(self.SYNC_WORD)
                  if sync_idx == -1:
                      return None
                  
                  # Check minimum packet size
                  start_idx = sync_idx + len(self.SYNC_WORD)
                  if len(data) < start_idx + 5 + self.CRC_SIZE:
                      return None
                  
                  # Extract header fields
                  src_id = data[start_idx]
                  dst_id = data[start_idx + 1]
                  seq_num = data[start_idx + 2]
                  pkt_type = data[start_idx + 3]
                  payload_len = data[start_idx + 4]
                  
                  # Check if we have complete packet
                  total_len = start_idx + 5 + payload_len + self.CRC_SIZE
                  if len(data) < total_len:
                      return None
                  
                  # Extract payload and CRC
                  payload = data[start_idx + 5:start_idx + 5 + payload_len]
                  rx_crc = struct.unpack('>H', data[total_len - self.CRC_SIZE:total_len])[0]
                  
                  # Verify CRC
                  crc_data = data[start_idx:total_len - self.CRC_SIZE]
                  calc_crc = self.calculate_crc16(crc_data)
                  
                  if rx_crc != calc_crc:
                      self.stats['crc_errors'] += 1
                      print(f"[Node {self.node_id}] CRC mismatch (expected: {calc_crc:04X}, got: {rx_crc:04X})")
                      return None
                  
                  return {
                      'src': src_id,
                      'dst': dst_id,
                      'seq': seq_num,
                      'type': pkt_type,
                      'payload': payload,
                      'consumed': total_len
                  }
              except Exception as e:
                  print(f"[Node {self.node_id}] Error parsing packet: {e}")
                  return None
          
          def tx_handler(self):
              """Thread for handling packet transmission with ARQ"""
              while self.running:
                  try:
                      # Get message from queue (with timeout for thread safety)
                      try:
                          msg = self.tx_queue.get(timeout=0.1)
                      except queue.Empty:
                          continue
                      
                      # ALOHA: Random backoff
                      if random.random() > self.aloha_prob:
                          backoff_time = random.uniform(0.1, 0.5)
                          print(f"[Node {self.node_id}] ALOHA backoff {backoff_time:.2f}s")
                          time.sleep(backoff_time)
                          # Re-queue the message
                          self.tx_queue.put(msg)
                          continue
                      
                      # Prepare packet
                      with self.lock:
                          seq_num = self.seq_num_tx
                          self.seq_num_tx = (self.seq_num_tx + 1) % 256
                      
                      packet = self.create_packet(
                          msg['dst'],
                          seq_num,
                          msg['type'],
                          msg.get('data', b'')
                      )
                      
                      # Stop-and-Wait ARQ
                      retries = 0
                      ack_received = False
                      
                      while retries < self.max_retries and not ack_received:
                          # Transmit packet
                          print(f"[Node {self.node_id}] TX: Sending packet seq={seq_num} to node {msg['dst']} (attempt {retries + 1})")
                          self.transmit_packet(packet)
                          self.stats['packets_sent'] += 1
                          
                          if retries > 0:
                              self.stats['retransmissions'] += 1
                          
                          # Wait for ACK
                          ack_key = f"{msg['dst']}_{seq_num}"
                          timeout_time = time.time() + self.timeout
                          
                          while time.time() < timeout_time:
                              try:
                                  ack = self.ack_queue.get(timeout=0.1)
                                  if ack['key'] == ack_key:
                                      ack_received = True
                                      self.stats['acks_received'] += 1
                                      print(f"[Node {self.node_id}] TX: ACK received for seq={seq_num}")
                                      break
                              except queue.Empty:
                                  pass
                          
                          if not ack_received:
                              retries += 1
                              if retries < self.max_retries:
                                  print(f"[Node {self.node_id}] TX: Timeout, retry {retries}/{self.max_retries}")
                      
                      if not ack_received:
                          print(f"[Node {self.node_id}] TX: Failed to deliver packet seq={seq_num} after {self.max_retries} attempts")
                          
                  except Exception as e:
                      print(f"[Node {self.node_id}] TX handler error: {e}")
          
          def rx_handler(self):
              """Thread for handling packet reception"""
              while self.running:
                  try:
                      # Get received data
                      try:
                          rx_data = self.rx_queue.get(timeout=0.1)
                      except queue.Empty:
                          continue
                      
                      # Add to buffer
                      self.rx_buffer += rx_data
                      
                      # Try to parse packets from buffer
                      while len(self.rx_buffer) > 0:
                          pkt = self.parse_packet(self.rx_buffer)
                          
                          if pkt is None:
                              # No valid packet found, remove first byte and try again
                              if len(self.rx_buffer) > 1:
                                  self.rx_buffer = self.rx_buffer[1:]
                              else:
                                  self.rx_buffer = bytes()
                              continue
                          
                          # Remove processed packet from buffer
                          self.rx_buffer = self.rx_buffer[pkt['consumed']:]
                          
                          # Check if packet is for this node or broadcast
                          if pkt['dst'] != self.node_id and pkt['dst'] != 0xFF:
                              print(f"[Node {self.node_id}] RX: Packet not for us (dst={pkt['dst']})")
                              continue
                          
                          # Handle based on packet type
                          if pkt['type'] == self.PKT_DATA:
                              self.stats['packets_received'] += 1
                              print(f"[Node {self.node_id}] RX: Data packet from node {pkt['src']}, seq={pkt['seq']}")
                              
                              # Check for duplicate
                              is_duplicate = False
                              if pkt['src'] in self.seq_num_rx:
                                  if self.seq_num_rx[pkt['src']] == pkt['seq']:
                                      print(f"[Node {self.node_id}] RX: Duplicate packet detected")
                                      is_duplicate = True
                              
                              self.seq_num_rx[pkt['src']] = pkt['seq']
                              
                              # Send ACK
                              ack_packet = self.create_packet(
                                  pkt['src'],
                                  pkt['seq'],
                                  self.PKT_ACK
                              )
                              print(f"[Node {self.node_id}] RX: Sending ACK for seq={pkt['seq']}")
                              self.transmit_packet(ack_packet)
                              self.stats['acks_sent'] += 1
                              
                              # Forward to application if not duplicate
                              if not is_duplicate:
                                  self.forward_to_app(pkt['src'], pkt['payload'])
                              
                          elif pkt['type'] == self.PKT_ACK:
                              print(f"[Node {self.node_id}] RX: ACK packet from node {pkt['src']}, seq={pkt['seq']}")
                              # Process ACK
                              ack_key = f"{pkt['src']}_{pkt['seq']}"
                              self.ack_queue.put({'key': ack_key})
                              
                  except Exception as e:
                      print(f"[Node {self.node_id}] RX handler error: {e}")
          
          def transmit_packet(self, packet):
              """Send packet to physical layer"""
              try:
                  # Convert to PDU format
                  vec = pmt.init_u8vector(len(packet), list(packet))
                  pdu = pmt.cons(pmt.PMT_NIL, vec)
                  
                  # Send to modulator
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)
                  
              except Exception as e:
                  print(f"[Node {self.node_id}] Error transmitting packet: {e}")
          
          def forward_to_app(self, src_id, data):
              """Forward received data to application/GUI"""
              try:
                  # Decode message
                  message = data.decode('utf-8', errors='ignore')
                  
                  # Create formatted output string
                  output = f"[From Node {src_id}]: {message}"
                  
                  # Send as simple string message
                  msg = pmt.intern(output)
                  self.message_port_pub(pmt.intern('msg_out'), msg)
                  
                  # Also send as dictionary for more complex processing
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("src"), pmt.from_long(src_id))
                  meta = pmt.dict_add(meta, pmt.intern("data"), pmt.intern(message))
                  
                  print(f"[Node {self.node_id}] Message delivered: {output}")
                  
              except Exception as e:
                  print(f"[Node {self.node_id}] Error forwarding to app: {e}")
          
          def work(self, input_items, output_items):
              """Main work function (not used for message passing blocks)"""
              return 0
          
          def stop(self):
              """Clean shutdown"""
              print(f"\n[Node {self.node_id}] Statistics:")
              print(f"  Packets sent: {self.stats['packets_sent']}")
              print(f"  Packets received: {self.stats['packets_received']}")
              print(f"  ACKs sent: {self.stats['acks_sent']}")
              print(f"  ACKs received: {self.stats['acks_received']}")
              print(f"  Retransmissions: {self.stats['retransmissions']}")
              print(f"  CRC errors: {self.stats['crc_errors']}")
              
              self.running = False
              if self.tx_thread.is_alive():
                  self.tx_thread.join()
              if self.rx_thread.is_alive():
                  self.rx_thread.join()
              return True
    aloha_prob: '0.5'
    max_retries: '3'
    node_id: '2'
    timeout: '1'
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nfrom gnuradio import gr\nfrom PyQt5 import QtWidgets, QtCore, QtGui\nimport sys\nimport pmt\nimport time\nfrom datetime import datetime  # for timestamps\n\nclass WallpaperScrollArea(QtWidgets.QScrollArea):\n    def __init__(self, bg_image=\"\", parent=None):\n        super().__init__(parent)\n        self.setWidgetResizable(True)\n        self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)\n        self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None\n\n    def paintEvent(self, event):\n        if self.bg_pixmap:\n            painter = QtGui.QPainter(self.viewport())\n            painter.drawPixmap(self.viewport().rect(), self.bg_pixmap)\n        super().paintEvent(event)\n\n\nclass messenger_gui(gr.basic_block):\n    \"\"\"\n    WhatsApp-style Messenger GUI with dynamic bubble resizing,\n    horizontal scroll for long messages, timestamp update on delivery,\n    and failure indication if retry limit is exceeded.\n    \"\"\"\n\n    def __init__(self, bg_image=\"\"):\n        gr.basic_block.__init__(\n            self,\n            name=\"Messenger GUI\",\n            in_sig=None,\n            out_sig=None,\n        )\n\n        # Message ports\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.message_port_register_in(pmt.intern(\"feedback\"))\n        self.set_msg_handler(pmt.intern(\"feedback\"), self._process_feedback)\n\n        # Qt Application\n        self.app = QtWidgets.QApplication.instance()\n        if self.app is None:\n            self.app = QtWidgets.QApplication(sys.argv)\n\n        self.qt_widget = QtWidgets.QWidget()\n        self.qt_widget.setWindowTitle(\"Messenger GUI\")\n        self.qt_widget.resize(600, 500)\n\n        main_layout = QtWidgets.QVBoxLayout()\n        main_layout.setContentsMargins(0, 0, 0, 0)\n        main_layout.setSpacing(0)\n        self.qt_widget.setLayout(main_layout)\n\n        # Scroll area with background\n        self.scroll_area = WallpaperScrollArea(bg_image=bg_image)\n        self.scroll_area.setStyleSheet(\"border: none;\")\n        self.scroll_area.setWidgetResizable(True)\n        main_layout.addWidget(self.scroll_area, stretch=1)\n\n        # Chat container\n        self.chat_container = QtWidgets.QWidget()\n        self.chat_layout = QtWidgets.QVBoxLayout()\n        self.chat_layout.setAlignment(QtCore.Qt.AlignTop)\n        self.chat_layout.setSpacing(10)\n        self.chat_container.setLayout(self.chat_layout)\n        self.chat_container.setStyleSheet(\"background: transparent;\")\n        self.scroll_area.setWidget(self.chat_container)\n\n        # Input area\n        input_layout = QtWidgets.QHBoxLayout()\n        self.input_box = QtWidgets.QLineEdit()\n        self.input_box.setPlaceholderText(\"Type a message...\")\n        self.input_box.setStyleSheet(\"\"\"\n            QLineEdit {\n                border-radius: 15px;\n                padding: 12px;\n                background-color: rgba(255,255,255,230);\n                font-size: 32px;\n            }\n        \"\"\")\n        self.send_button = QtWidgets.QPushButton(\"Send\")\n        self.send_button.setStyleSheet(\"\"\"\n            QPushButton {\n                background-color: #4CAF50;\n                color: white;\n                border-radius: 15px;\n                padding: 12px 24px;\n                font-weight: bold;\n                font-size: 32px;\n            }\n            QPushButton:hover {\n                background-color: #45a049;\n            }\n        \"\"\")\n        input_layout.addWidget(self.input_box)\n        input_layout.addWidget(self.send_button)\n        main_layout.addLayout(input_layout)\n\n        # Connect signals\n        self.send_button.clicked.connect(self.send_message)\n        self.input_box.returnPressed.connect(self.send_message)\n\n        self._last_message_timestamp = None\n        self.qt_widget.show()\n\n    def send_message(self):\n        text = self.input_box.text().strip()\n        if not text:\n            return\n\n        # Send message via GNU Radio port\n        # self.message_port_pub(pmt.intern(\"out\"), pmt.string_to_symbol(text))\n\n        # encode the text as UTF-8 bytes\n        text_b = text.encode('utf-8')\n        # create PMT u8vector from the bytes\n        vec = pmt.init_u8vector(len(text_b), bytearray(text_b))\n        # create PDU pair (meta, data). Use PMT_NIL if no metadata is needed.\n        pdu = pmt.cons(pmt.PMT_NIL, vec)\n        # publish the PDU on the \"out\" port\n        self.message_port_pub(pmt.intern(\"out\"), pdu)\n\n\n        # Scrollable bubble container\n        scroll = QtWidgets.QScrollArea()\n        scroll.setWidgetResizable(True)\n        scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)\n        scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)\n        scroll.setStyleSheet(\"border: none; background: transparent;\")\n\n        # Message bubble\n        bubble = QtWidgets.QLabel(text)\n        bubble.setWordWrap(False)  # Disable wrapping\n        bubble.setStyleSheet(\"\"\"\n            QLabel {\n                background-color: qlineargradient(x1:0, y1:0, x2:1, y2:1,\n                    stop:0 #4CAF50, stop:1 #66BB6A);\n                color: white;\n                border-radius: 15px;\n                padding: 10px 15px;\n                font-size: 32px;\n            }\n        \"\"\")\n\n        # Shadow effect\n        effect = QtWidgets.QGraphicsDropShadowEffect()\n        effect.setBlurRadius(6)\n        effect.setXOffset(2)\n        effect.setYOffset(2)\n        effect.setColor(QtGui.QColor(0, 0, 0, 100))\n        bubble.setGraphicsEffect(effect)\n\n        scroll.setWidget(bubble)\n        scroll.setMinimumWidth(200)\n        scroll.setMaximumWidth(550)  # Max visible width of bubble\n        bubble.adjustSize()\n        scroll.adjustSize()\n\n        # Timestamp label as small blue pill initially\n        timestamp = QtWidgets.QLabel(\"Sending...\")\n        timestamp.setStyleSheet(\"\"\"\n            QLabel {\n                background-color: #2196F3;  /* blue background */\n                color: white;\n                font-size: 18px;\n                border-radius: 8px;\n                padding: 2px 6px;\n            }\n        \"\"\")\n        timestamp.setAlignment(QtCore.Qt.AlignRight)\n        timestamp.setSizePolicy(QtWidgets.QSizePolicy.Fixed, QtWidgets.QSizePolicy.Fixed)\n\n        # Container for bubble + timestamp\n        container = QtWidgets.QWidget()\n        vbox = QtWidgets.QVBoxLayout()\n        vbox.setContentsMargins(0, 0, 0, 0)\n        vbox.setSpacing(2)\n        vbox.addWidget(scroll)\n        vbox.addWidget(timestamp, alignment=QtCore.Qt.AlignRight)\n        container.setLayout(vbox)\n        container.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Fixed)\n\n        # Add to chat layout\n        self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignRight)\n\n        # Force proper size recalculation\n        bubble.adjustSize()\n        scroll.adjustSize()\n        container.adjustSize()\n        self.chat_container.adjustSize()\n        QtWidgets.QApplication.processEvents()  # Force layout update\n\n        # Scroll to bottom\n        QtCore.QTimer.singleShot(50, lambda: self.scroll_area.verticalScrollBar().setValue(\n            self.scroll_area.verticalScrollBar().maximum()\n        ))\n\n        self.input_box.clear()\n        self._last_message_timestamp = timestamp\n\n    def _process_feedback(self, msg):\n        try:\n            if pmt.is_symbol(msg):\n                feedback = pmt.symbol_to_string(msg)\n\n                if feedback == \"END_ACK_RECEIVED\" and self._last_message_timestamp:\n                    # Successful delivery: show current time in blue pill\n                    self._last_message_timestamp.setText(datetime.now().strftime(\"%H:%M\"))\n                    self._last_message_timestamp.setStyleSheet(\"\"\"\n                        QLabel {\n                            background-color: #2196F3;  /* blue background */\n                            color: white;\n                            font-size: 18px;\n                            border-radius: 8px;\n                            padding: 2px 6px;\n                        }\n                    \"\"\")\n\n                elif feedback == \"RETRY_LIMIT_EXCEEDED\" and self._last_message_timestamp:\n                    # Failed delivery: red pill\n                    self._last_message_timestamp.setText(\"Failed\")\n                    self._last_message_timestamp.setStyleSheet(\"\"\"\n                        QLabel {\n                            background-color: #F44336;  /* red background */\n                            color: white;\n                            font-size: 18px;\n                            border-radius: 8px;\n                            padding: 2px 6px;\n                        }\n                    \"\"\")\n\n        except Exception as e:\n            print(f\"[messenger_gui] Error processing feedback: {e}\")\n\n"
    bg_image: '''/home/vboxuser/Downloads/tx.jpg'''
  states: {state: disabled}
- name: epy_block_0_1_0_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nfrom gnuradio import gr\nfrom PyQt5 import QtWidgets, QtCore, QtGui\nimport sys\nimport pmt\nimport time\nfrom datetime import datetime  # for timestamps\n\nclass WallpaperScrollArea(QtWidgets.QScrollArea):\n    def __init__(self, bg_image=\"\", parent=None):\n        super().__init__(parent)\n        self.setWidgetResizable(True)\n        self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)\n        self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None\n\n    def paintEvent(self, event):\n        if self.bg_pixmap:\n            painter = QtGui.QPainter(self.viewport())\n            painter.drawPixmap(self.viewport().rect(), self.bg_pixmap)\n        super().paintEvent(event)\n\n\nclass messenger_gui(gr.basic_block):\n    \"\"\"\n    WhatsApp-style Messenger GUI with dynamic bubble resizing,\n    horizontal scroll for long messages, timestamp update on delivery,\n    and failure indication if retry limit is exceeded.\n    \"\"\"\n\n    def __init__(self, bg_image=\"\"):\n        gr.basic_block.__init__(\n            self,\n            name=\"Messenger GUI\",\n            in_sig=None,\n            out_sig=None,\n        )\n\n        # Message ports\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.message_port_register_in(pmt.intern(\"feedback\"))\n        self.set_msg_handler(pmt.intern(\"feedback\"), self._process_feedback)\n\n        # Qt Application\n        self.app = QtWidgets.QApplication.instance()\n        if self.app is None:\n            self.app = QtWidgets.QApplication(sys.argv)\n\n        self.qt_widget = QtWidgets.QWidget()\n        self.qt_widget.setWindowTitle(\"Messenger GUI\")\n        self.qt_widget.resize(600, 500)\n\n        main_layout = QtWidgets.QVBoxLayout()\n        main_layout.setContentsMargins(0, 0, 0, 0)\n        main_layout.setSpacing(0)\n        self.qt_widget.setLayout(main_layout)\n\n        # Scroll area with background\n        self.scroll_area = WallpaperScrollArea(bg_image=bg_image)\n        self.scroll_area.setStyleSheet(\"border: none;\")\n        self.scroll_area.setWidgetResizable(True)\n        main_layout.addWidget(self.scroll_area, stretch=1)\n\n        # Chat container\n        self.chat_container = QtWidgets.QWidget()\n        self.chat_layout = QtWidgets.QVBoxLayout()\n        self.chat_layout.setAlignment(QtCore.Qt.AlignTop)\n        self.chat_layout.setSpacing(10)\n        self.chat_container.setLayout(self.chat_layout)\n        self.chat_container.setStyleSheet(\"background: transparent;\")\n        self.scroll_area.setWidget(self.chat_container)\n\n        # Input area\n        input_layout = QtWidgets.QHBoxLayout()\n        self.input_box = QtWidgets.QLineEdit()\n        self.input_box.setPlaceholderText(\"Type a message...\")\n        self.input_box.setStyleSheet(\"\"\"\n            QLineEdit {\n                border-radius: 15px;\n                padding: 12px;\n                background-color: rgba(255,255,255,230);\n                font-size: 32px;\n            }\n        \"\"\")\n        self.send_button = QtWidgets.QPushButton(\"Send\")\n        self.send_button.setStyleSheet(\"\"\"\n            QPushButton {\n                background-color: #4CAF50;\n                color: white;\n                border-radius: 15px;\n                padding: 12px 24px;\n                font-weight: bold;\n                font-size: 32px;\n            }\n            QPushButton:hover {\n                background-color: #45a049;\n            }\n        \"\"\")\n        input_layout.addWidget(self.input_box)\n        input_layout.addWidget(self.send_button)\n        main_layout.addLayout(input_layout)\n\n        # Connect signals\n        self.send_button.clicked.connect(self.send_message)\n        self.input_box.returnPressed.connect(self.send_message)\n\n        self._last_message_timestamp = None\n        self.qt_widget.show()\n\n    def send_message(self):\n        text = self.input_box.text().strip()\n        if not text:\n            return\n\n        # Send message via GNU Radio port\n        # self.message_port_pub(pmt.intern(\"out\"), pmt.string_to_symbol(text))\n\n        # encode the text as UTF-8 bytes\n        text_b = text.encode('utf-8')\n        # create PMT u8vector from the bytes\n        vec = pmt.init_u8vector(len(text_b), bytearray(text_b))\n        # create PDU pair (meta, data). Use PMT_NIL if no metadata is needed.\n        pdu = pmt.cons(pmt.PMT_NIL, vec)\n        # publish the PDU on the \"out\" port\n        self.message_port_pub(pmt.intern(\"out\"), pdu)\n\n\n        # Scrollable bubble container\n        scroll = QtWidgets.QScrollArea()\n        scroll.setWidgetResizable(True)\n        scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)\n        scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)\n        scroll.setStyleSheet(\"border: none; background: transparent;\")\n\n        # Message bubble\n        bubble = QtWidgets.QLabel(text)\n        bubble.setWordWrap(False)  # Disable wrapping\n        bubble.setStyleSheet(\"\"\"\n            QLabel {\n                background-color: qlineargradient(x1:0, y1:0, x2:1, y2:1,\n                    stop:0 #4CAF50, stop:1 #66BB6A);\n                color: white;\n                border-radius: 15px;\n                padding: 10px 15px;\n                font-size: 32px;\n            }\n        \"\"\")\n\n        # Shadow effect\n        effect = QtWidgets.QGraphicsDropShadowEffect()\n        effect.setBlurRadius(6)\n        effect.setXOffset(2)\n        effect.setYOffset(2)\n        effect.setColor(QtGui.QColor(0, 0, 0, 100))\n        bubble.setGraphicsEffect(effect)\n\n        scroll.setWidget(bubble)\n        scroll.setMinimumWidth(200)\n        scroll.setMaximumWidth(550)  # Max visible width of bubble\n        bubble.adjustSize()\n        scroll.adjustSize()\n\n        # Timestamp label as small blue pill initially\n        timestamp = QtWidgets.QLabel(\"Sending...\")\n        timestamp.setStyleSheet(\"\"\"\n            QLabel {\n                background-color: #2196F3;  /* blue background */\n                color: white;\n                font-size: 18px;\n                border-radius: 8px;\n                padding: 2px 6px;\n            }\n        \"\"\")\n        timestamp.setAlignment(QtCore.Qt.AlignRight)\n        timestamp.setSizePolicy(QtWidgets.QSizePolicy.Fixed, QtWidgets.QSizePolicy.Fixed)\n\n        # Container for bubble + timestamp\n        container = QtWidgets.QWidget()\n        vbox = QtWidgets.QVBoxLayout()\n        vbox.setContentsMargins(0, 0, 0, 0)\n        vbox.setSpacing(2)\n        vbox.addWidget(scroll)\n        vbox.addWidget(timestamp, alignment=QtCore.Qt.AlignRight)\n        container.setLayout(vbox)\n        container.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Fixed)\n\n        # Add to chat layout\n        self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignRight)\n\n        # Force proper size recalculation\n        bubble.adjustSize()\n        scroll.adjustSize()\n        container.adjustSize()\n        self.chat_container.adjustSize()\n        QtWidgets.QApplication.processEvents()  # Force layout update\n\n        # Scroll to bottom\n        QtCore.QTimer.singleShot(50, lambda: self.scroll_area.verticalScrollBar().setValue(\n            self.scroll_area.verticalScrollBar().maximum()\n        ))\n\n        self.input_box.clear()\n        self._last_message_timestamp = timestamp\n\n    def _process_feedback(self, msg):\n        try:\n            if pmt.is_symbol(msg):\n                feedback = pmt.symbol_to_string(msg)\n\n                if feedback == \"END_ACK_RECEIVED\" and self._last_message_timestamp:\n                    # Successful delivery: show current time in blue pill\n                    self._last_message_timestamp.setText(datetime.now().strftime(\"%H:%M\"))\n                    self._last_message_timestamp.setStyleSheet(\"\"\"\n                        QLabel {\n                            background-color: #2196F3;  /* blue background */\n                            color: white;\n                            font-size: 18px;\n                            border-radius: 8px;\n                            padding: 2px 6px;\n                        }\n                    \"\"\")\n\n                elif feedback == \"RETRY_LIMIT_EXCEEDED\" and self._last_message_timestamp:\n                    # Failed delivery: red pill\n                    self._last_message_timestamp.setText(\"Failed\")\n                    self._last_message_timestamp.setStyleSheet(\"\"\"\n                        QLabel {\n                            background-color: #F44336;  /* red background */\n                            color: white;\n                            font-size: 18px;\n                            border-radius: 8px;\n                            padding: 2px 6px;\n                        }\n                    \"\"\")\n\n        except Exception as e:\n            print(f\"[messenger_gui] Error processing feedback: {e}\")\n\n"
    bg_image: '''/home/vboxuser/Downloads/tx.jpg'''
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_to_bitstream(gr.sync_block):
          """
          Converts PDU messages to a framed bitstream.
          Frame format: [SYNC_WORD (4 bytes)] [LENGTH (2 bytes)] [DATA (N bytes)]
          Each byte is unpacked into 8 bits (MSB first).
          """
          def __init__(self, sync_word=0x1ACFFC1D):
              gr.sync_block.__init__(
                  self,
                  name="PDU to Bitstream",
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)
              
              self.sync_word = sync_word
              self.bit_buffer = []
              
          def handle_pdu(self, pdu):
              """Handle incoming PDU messages"""
              # Extract data from PDU (ignore metadata for now)
              data = pmt.cdr(pdu)
              
              # Convert PMT vector to numpy array
              if pmt.is_u8vector(data):
                  data_bytes = np.array(pmt.u8vector_elements(data), dtype=np.uint8)
              else:
                  return
              
              # Build frame: [SYNC][LENGTH][DATA]
              frame = []
              
              # Add sync word (4 bytes, big-endian)
              sync_bytes = np.array([
                  (self.sync_word >> 24) & 0xFF,
                  (self.sync_word >> 16) & 0xFF,
                  (self.sync_word >> 8) & 0xFF,
                  self.sync_word & 0xFF
              ], dtype=np.uint8)
              frame.extend(sync_bytes)
              
              # Add length (2 bytes, big-endian)
              length = len(data_bytes)
              length_bytes = np.array([
                  (length >> 8) & 0xFF,
                  length & 0xFF
              ], dtype=np.uint8)
              frame.extend(length_bytes)
              
              # Add data
              frame.extend(data_bytes)
              
              # Convert frame to numpy array and unpack to bits
              frame_array = np.array(frame, dtype=np.uint8)
              bits = np.unpackbits(frame_array)
              
              # Add bits to buffer
              self.bit_buffer.extend(bits.tolist())
          
          def work(self, input_items, output_items):
              """Output buffered bits"""
              out = output_items[0]
              
              # Determine how many bits to output
              n_output = min(len(self.bit_buffer), len(out))
              
              if n_output > 0:
                  # Copy bits to output
                  out[:n_output] = self.bit_buffer[:n_output]
                  # Remove outputted bits from buffer
                  self.bit_buffer = self.bit_buffer[n_output:]
                  
              return n_output
    sync_word: '0x1ACFFC1D'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_to_bitstream(gr.sync_block):
          """
          Converts PDU messages to a framed bitstream.
          Frame format: [SYNC_WORD (4 bytes)] [LENGTH (2 bytes)] [DATA (N bytes)]
          Each byte is unpacked into 8 bits (MSB first).
          """
          def __init__(self, sync_word=0x1ACFFC1D):
              gr.sync_block.__init__(
                  self,
                  name="PDU to Bitstream",
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)
              
              self.sync_word = sync_word
              self.bit_buffer = []
              
          def handle_pdu(self, pdu):
              """Handle incoming PDU messages"""
              # Extract data from PDU (ignore metadata for now)
              data = pmt.cdr(pdu)
              
              # Convert PMT vector to numpy array
              if pmt.is_u8vector(data):
                  data_bytes = np.array(pmt.u8vector_elements(data), dtype=np.uint8)
              else:
                  return
              
              # Build frame: [SYNC][LENGTH][DATA]
              frame = []
              
              # Add sync word (4 bytes, big-endian)
              sync_bytes = np.array([
                  (self.sync_word >> 24) & 0xFF,
                  (self.sync_word >> 16) & 0xFF,
                  (self.sync_word >> 8) & 0xFF,
                  self.sync_word & 0xFF
              ], dtype=np.uint8)
              frame.extend(sync_bytes)
              
              # Add length (2 bytes, big-endian)
              length = len(data_bytes)
              length_bytes = np.array([
                  (length >> 8) & 0xFF,
                  length & 0xFF
              ], dtype=np.uint8)
              frame.extend(length_bytes)
              
              # Add data
              frame.extend(data_bytes)
              
              # Convert frame to numpy array and unpack to bits
              frame_array = np.array(frame, dtype=np.uint8)
              bits = np.unpackbits(frame_array)
              
              # Add bits to buffer
              self.bit_buffer.extend(bits.tolist())
          
          def work(self, input_items, output_items):
              """Output buffered bits"""
              out = output_items[0]
              
              # Determine how many bits to output
              n_output = min(len(self.bit_buffer), len(out))
              
              if n_output > 0:
                  # Copy bits to output
                  out[:n_output] = self.bit_buffer[:n_output]
                  # Remove outputted bits from buffer
                  self.bit_buffer = self.bit_buffer[n_output:]
                  
              return n_output
    sync_word: '0x1ACFFC1D'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt

      class bitstream_to_pdu(gr.sync_block):
          """
          Converts a framed bitstream back to PDU messages.
          Searches for sync word and reconstructs PDUs based on length field.
          Frame format: [SYNC_WORD (4 bytes)] [LENGTH (2 bytes)] [DATA (N bytes)]
          """
          def __init__(self, sync_word=0x1ACFFC1D, threshold=0):
              gr.sync_block.__init__(
                  self,
                  name="Bitstream to PDU",
                  in_sig=[np.uint8],
                  out_sig=None
              )
              
              self.message_port_register_out(pmt.intern('pdu_out'))
              
              self.sync_word = sync_word
              self.threshold = threshold  # Number of bit errors allowed in sync
              
              # Convert sync word to bit pattern
              sync_bytes = np.array([
                  (sync_word >> 24) & 0xFF,
                  (sync_word >> 16) & 0xFF,
                  (sync_word >> 8) & 0xFF,
                  sync_word & 0xFF
              ], dtype=np.uint8)
              self.sync_bits = np.unpackbits(sync_bytes)
              
              self.bit_buffer = []
              self.state = 'SEARCH'  # States: SEARCH, READ_LENGTH, READ_DATA
              self.pdu_length = 0
              self.bits_needed = 0
              
          def correlate_sync(self, bits):
              """Check if bits match sync word (with threshold)"""
              if len(bits) < len(self.sync_bits):
                  return False
              
              errors = np.sum(bits[:len(self.sync_bits)] != self.sync_bits)
              return errors <= self.threshold
          
          def work(self, input_items, output_items):
              """Process input bitstream and reconstruct PDUs"""
              in0 = input_items[0]
              n_input = len(in0)
              
              # Add incoming bits to buffer
              self.bit_buffer.extend(in0[:n_input].tolist())
              
              # Process buffer based on current state
              while True:
                  if self.state == 'SEARCH':
                      # Search for sync word
                      if len(self.bit_buffer) >= len(self.sync_bits):
                          if self.correlate_sync(np.array(self.bit_buffer[:len(self.sync_bits)])):
                              # Found sync word, remove it from buffer
                              self.bit_buffer = self.bit_buffer[len(self.sync_bits):]
                              self.state = 'READ_LENGTH'
                          else:
                              # Shift by one bit and continue searching
                              self.bit_buffer.pop(0)
                      else:
                          break  # Not enough bits yet
                          
                  elif self.state == 'READ_LENGTH':
                      # Need 16 bits (2 bytes) for length
                      if len(self.bit_buffer) >= 16:
                          # Extract length bits and convert to bytes
                          length_bits = np.array(self.bit_buffer[:16], dtype=np.uint8)
                          length_bytes = np.packbits(length_bits)
                          self.pdu_length = (int(length_bytes[0]) << 8) | int(length_bytes[1])
                          
                          # Remove length bits from buffer
                          self.bit_buffer = self.bit_buffer[16:]
                          
                          # Calculate bits needed for data
                          self.bits_needed = self.pdu_length * 8
                          self.state = 'READ_DATA'
                      else:
                          break  # Not enough bits yet
                          
                  elif self.state == 'READ_DATA':
                      # Check if we have all data bits
                      if len(self.bit_buffer) >= self.bits_needed:
                          # Extract data bits
                          data_bits = np.array(self.bit_buffer[:self.bits_needed], dtype=np.uint8)
                          self.bit_buffer = self.bit_buffer[self.bits_needed:]
                          
                          # Pack bits back into bytes
                          data_bytes = np.packbits(data_bits)
                          
                          # Create and send PDU (with empty metadata)
                          pdu_vector = pmt.init_u8vector(len(data_bytes), data_bytes.tolist())
                          pdu = pmt.cons(pmt.make_dict(), pdu_vector)
                          self.message_port_pub(pmt.intern('pdu_out'), pdu)
                          
                          # Go back to searching for next frame
                          self.state = 'SEARCH'
                      else:
                          break  # Not enough bits yet
              
              return n_input
    sync_word: '0x1ACFFC1D'
    threshold: '1'
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt

      class bitstream_to_pdu(gr.sync_block):
          """
          Converts a framed bitstream back to PDU messages.
          Searches for sync word and reconstructs PDUs based on length field.
          Frame format: [SYNC_WORD (4 bytes)] [LENGTH (2 bytes)] [DATA (N bytes)]
          """
          def __init__(self, sync_word=0x1ACFFC1D, threshold=0):
              gr.sync_block.__init__(
                  self,
                  name="Bitstream to PDU",
                  in_sig=[np.uint8],
                  out_sig=None
              )
              
              self.message_port_register_out(pmt.intern('pdu_out'))
              
              self.sync_word = sync_word
              self.threshold = threshold  # Number of bit errors allowed in sync
              
              # Convert sync word to bit pattern
              sync_bytes = np.array([
                  (sync_word >> 24) & 0xFF,
                  (sync_word >> 16) & 0xFF,
                  (sync_word >> 8) & 0xFF,
                  sync_word & 0xFF
              ], dtype=np.uint8)
              self.sync_bits = np.unpackbits(sync_bytes)
              
              self.bit_buffer = []
              self.state = 'SEARCH'  # States: SEARCH, READ_LENGTH, READ_DATA
              self.pdu_length = 0
              self.bits_needed = 0
              
          def correlate_sync(self, bits):
              """Check if bits match sync word (with threshold)"""
              if len(bits) < len(self.sync_bits):
                  return False
              
              errors = np.sum(bits[:len(self.sync_bits)] != self.sync_bits)
              return errors <= self.threshold
          
          def work(self, input_items, output_items):
              """Process input bitstream and reconstruct PDUs"""
              in0 = input_items[0]
              n_input = len(in0)
              
              # Add incoming bits to buffer
              self.bit_buffer.extend(in0[:n_input].tolist())
              
              # Process buffer based on current state
              while True:
                  if self.state == 'SEARCH':
                      # Search for sync word
                      if len(self.bit_buffer) >= len(self.sync_bits):
                          if self.correlate_sync(np.array(self.bit_buffer[:len(self.sync_bits)])):
                              # Found sync word, remove it from buffer
                              self.bit_buffer = self.bit_buffer[len(self.sync_bits):]
                              self.state = 'READ_LENGTH'
                          else:
                              # Shift by one bit and continue searching
                              self.bit_buffer.pop(0)
                      else:
                          break  # Not enough bits yet
                          
                  elif self.state == 'READ_LENGTH':
                      # Need 16 bits (2 bytes) for length
                      if len(self.bit_buffer) >= 16:
                          # Extract length bits and convert to bytes
                          length_bits = np.array(self.bit_buffer[:16], dtype=np.uint8)
                          length_bytes = np.packbits(length_bits)
                          self.pdu_length = (int(length_bytes[0]) << 8) | int(length_bytes[1])
                          
                          # Remove length bits from buffer
                          self.bit_buffer = self.bit_buffer[16:]
                          
                          # Calculate bits needed for data
                          self.bits_needed = self.pdu_length * 8
                          self.state = 'READ_DATA'
                      else:
                          break  # Not enough bits yet
                          
                  elif self.state == 'READ_DATA':
                      # Check if we have all data bits
                      if len(self.bit_buffer) >= self.bits_needed:
                          # Extract data bits
                          data_bits = np.array(self.bit_buffer[:self.bits_needed], dtype=np.uint8)
                          self.bit_buffer = self.bit_buffer[self.bits_needed:]
                          
                          # Pack bits back into bytes
                          data_bytes = np.packbits(data_bits)
                          
                          # Create and send PDU (with empty metadata)
                          pdu_vector = pmt.init_u8vector(len(data_bytes), data_bytes.tolist())
                          pdu = pmt.cons(pmt.make_dict(), pdu_vector)
                          self.message_port_pub(pmt.intern('pdu_out'), pdu)
                          
                          # Go back to searching for next frame
                          self.state = 'SEARCH'
                      else:
                          break  # Not enough bits yet
              
              return n_input
    sync_word: '0x1ACFFC1D'
    threshold: '1'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, epy_block_0, msg_in]
- [blocks_message_strobe_0_0, strobe, epy_block_0_0, msg_in]
- [epy_block_0, msg_out, blocks_message_debug_0_0, print]
- [epy_block_0, pdu_out, epy_block_1, pdu_in]
- [epy_block_0_0, msg_out, blocks_message_debug_0, print]
- [epy_block_0_0, pdu_out, epy_block_1_0, pdu_in]
- [epy_block_0_1_0, out, epy_block_0, msg_in]
- [epy_block_0_1_0_0, out, epy_block_0_0, msg_in]
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_1_0, '0', epy_block_2_0, '0']
- [epy_block_2, pdu_out, epy_block_0_0, pdu_in]
- [epy_block_2_0, pdu_out, epy_block_0, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
