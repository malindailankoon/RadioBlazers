options:
  parameters:
    author: malindatemp
    generate_options: qt_gui
    id: testing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: MTU
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: excess_bw_0
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_0
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 768e3
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: default
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ./output.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    FileName: InFile
    Pkt_len: '52'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\nimport struct\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source to Tagged Stream',\n            in_sig=None,\n            out_sig=[np.uint8])\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len\n        self.state = 0      \n        self.indx = 0\n        self._debug = 0     \n        self.data = \"\"\n        self.address = 0xC001D00D           #address \n        self.seq_num = 0                    #seq number of packet being sent\n        self.sync_word = b'%SYNC%'          #syncword to denote start of packet\n        self.crc = 0\n        self.poly = 0x104C11DB7\n        n_bytes = 32                        #length of in-packet preamble\n\n        if (os.path.exists(self.FileName)):\n            # open input file\n            self.f_in = open (self.FileName, 'rb')\n            self._eof = False\n            if (self._debug):\n                print (\"File name:\", self.FileName)\n            self.state = 1\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        #preamble consists of 01 repeating n times\n        self.char_list = bytes([0x55]) * n_bytes\n        self.c_len = len (self.char_list)\n        if (self._debug):\n            print (\"Length of Preamble: \", self.c_len)\n\n    #will continously be looped by GNU\n    def work(self, input_items, output_items):\n\n        #we can probably have a conditional here to check if the file is True or Not\n        #if its still waiting for ACK will go to state 0\n\n        if (self.state == 0):\n            # idle state\n            self.seq_num=0\n            if (self._debug):\n                print(\"State: 0\")\n            return (0)\n\n        elif (self.state == 1):\n            # send preamble state\n            if (self._debug):\n                print(\"State: 1\")\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.c_len)\n            self.add_item_tag(0,    # Write to output port 0\n                self.indx,          # Index of the tag\n                key1,               # Key of the tag\n                val1                # Value of the tag\n                )\n            self.indx += self.c_len\n            i = 0\n            while (i < self.c_len):\n                output_items[0][i] = self.char_list[i]\n                i += 1\n            #changing to state 2 after sending one preamble of n length\n            self.state = 2      \n            return (self.c_len)\n\n        elif (self.state == 2):\n            # send message packet state\n            while (not (self._eof)):\n\n                #needs to be edited to read from the queue\n\n                buff = self.f_in.read (self.Pkt_len)\n                b_len = len(buff)\n                if b_len == 0:\n                    print ('End of file')\n                    self._eof = True\n                    self.f_in.close()\n                    self.state = 3      \n                    self.pre_count = 0\n                    break\n                #crc generation\n                data = int.from_bytes(buff, byteorder='big')\n                data <<= 32\n                poly_length = self.poly.bit_length()\n                while data.bit_length() >= poly_length:\n                    data ^= self.poly << (data.bit_length() - poly_length)\n                #crc is 32 bit fixed length\n                self.crc = data.to_bytes(4, byteorder='big')\n                encoded = buff\n                #header generation, H = 2 bytes; I = 4 bytes;\n                self.header = struct.pack(\">H I I\", self.seq_num, self.address, len(encoded))\n                prepend = self.sync_word + self.header\n                encoded = prepend + encoded + self.crc\n                e_len = len(encoded)\n                self.seq_num+=1\n                if (self._debug):\n                    print ('b64 length =', e_len)\n                key0 = pmt.intern(\"packet_len\")\n                val0 = pmt.from_long(e_len)\n                self.add_item_tag(0,    # Write to output port 0\n                    self.indx,          # Index of the tag\n                    key0,               # Key of the tag\n                    val0                # Value of the tag\n                    )\n                self.indx += e_len\n                i = 0\n                while (i < e_len):\n                    output_items[0][i] = encoded[i]\n                    i += 1\n                #changing the state to 1, to resend preamble again after a packet is sent\n                self.state = 1\n                return (e_len)\n\n        return (0)\n\n\n"
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}

connections:
- [blocks_repack_bits_bb_1, '0', blocks_file_sink_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_constellation_decoder_cb_0_1, '0', digital_diff_decoder_bb_0_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_costas_loop_cc_0_1, '0', digital_constellation_decoder_cb_0_1, '0']
- [digital_diff_decoder_bb_0_1, '0', digital_map_bb_0_1, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_1, '0']
- [digital_map_bb_0_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_1, '0', blocks_tagged_stream_mux_0, '1']
- [epy_block_1, '0', digital_protocol_formatter_bb_0, '0']
- [virtual_source_0_0_0, '0', digital_costas_loop_cc_0_1, '0']
- [virtual_source_0_1, '0', digital_constellation_modulator_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
